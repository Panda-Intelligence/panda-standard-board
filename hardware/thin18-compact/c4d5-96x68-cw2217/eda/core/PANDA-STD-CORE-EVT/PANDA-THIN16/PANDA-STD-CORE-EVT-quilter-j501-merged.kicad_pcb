# Repository Panda-Intelligence/panda-standard-board

## KiCad design hardware/thin18-compact/c4d5-96x68-cw2217/eda/core/PANDA-STD-CORE-EVT/PANDA-THIN16/PANDA-STD-CORE-EVT-quilter-j501-merged.kicad_pcb

Parts:
C201: 47n / CBOOT; C201_CBOOT_0603_SEED
C202: 1u / VBUS; C202_CVBUS_0603_ENVELOPE
C203: 10u / PMID; C203_CPMID_1206_ENVELOPE
C204: 330n / ILIM-RC; C204_ILIM_RC_0603_SEED
C205: 4.7u / REGN; C205_CREGN_0805_ENVELOPE
C206: 10u / BAT; C206_CBAT_0805_ENVELOPE
C207: 22u / CSYS1; C207_CSYS_0805_ENVELOPE
C208: 22u / CSYS2; C208_CSYS_0805_ENVELOPE
C302: 100n / RTC VDD; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C303: 1u / BQ BAT; C_0402_1005Metric
C304: 2.2u / BQ VDD; C_0402_1005Metric
C401: 22u / VIN; C_0603_POWER_SEED
C402, C403: 22u / VOUT; C_0603_POWER_SEED
C501: 22u / ESP32; C_0805_2012Metric
C502: 100n / ESP32; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C503: 100n / VDD_IO; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C504: 100n / VDD; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C505: 100n / AUDIO_VDD; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C506: 10u / AUDIO_VDD; C_0603_1608Metric
C507: 1u / U405 VIN; C_0603_1608Metric; MPN 0603B105K250NT; LCSC C59302
C508: 1u / U402 VIN; C_0603_1608Metric; MPN 0603B105K250NT; LCSC C59302
C509: 1u / U403 VIN; C_0603_1608Metric; MPN 0603B105K250NT; LCSC C59302
C510: 1u / CHIP_PU; C_0603_1608Metric; MPN 0603B105K250NT; LCSC C59302
C511: 1u / U404 VIN; C_0603_1608Metric; MPN 0603B105K250NT; LCSC C59302
C512: 100n / SD VDD; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C513: 10u / SD VDD; C_0603_1608Metric
C601: 100n / U601 VCC; C_0402_1005Metric; MPN 0402B104K250NT; LCSC C56392
C903: 1u / CW2217 VCELL; C_0603_1608Metric; Voltage_Rating 25V; MPN 0603B105K250NT; LCSC C59302
J301: DF58-2P-1.2V(21); Hirose_DF58-2P-1.2V_1x02_P1.2mm_Vertical
J501: 104031-0811 / microSD; microSD_HC_Molex_104031-0811
J502: SM02B-SRSS-TB; JST_SH_SM02B-SRSS-TB_1x02-1MP_P1.00mm_Horizontal
J503: TC2030-IDC-NL / DEBUG; Tag-Connect_TC2030-IDC-NL_2x03_P1.27mm_Vertical
L401: 0.47uH / M0-PENDING; L401_XFL4015_ENVELOPE
L402: 2.2u / BQ buck; L402_2U2_ENVELOPE
R201: 5.6k / ILIM; R201_ILIM_0603_SEED
R204: 1.2k / ILIM-RC; R204_ILIM_RC_0603_SEED
R301: 1M / SCL PD DNP; R_0402_1005Metric; not fitted
R302: 1M / SDA PD DNP; R_0402_1005Metric; not fitted
R303: 10k / RTC EVI PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R304: 10k / VBACKUP no-backup / DNP with C301; R_0402_1005Metric; not fitted
R305: 100k / IRQ PU DNP; R_0402_1005Metric; not fitted
R306: 10m / CW2217 SHUNT; R_1206_3216Metric; Tolerance 1%; MPN FRM121WFR010TM; JLCPCB C7467248
R307: 10k / BIN PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744; not fitted
R501: 100k / IMU_INT1; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R502: 100k / EXP_INT_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R503: 10k / SD_MODE; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R504: 0R / GAIN 12dB; R_0402_1005Metric
R505: 100k / GAIN 15dB DNP; R_0402_1005Metric; not fitted
R506: 0R / GAIN 6dB DNP; R_0402_1005Metric; not fitted
R507: 100k / AUDIO_EN_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R508: 0R / MB6 AUDIO; R_0805_2012Metric
R509: 0R / MB2 3V3_AON; R_0805_2012Metric
R510: 10k / CHIP_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R511: 10k / GPIO0; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R512: 10k / GPIO3; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R513: 10k / GPIO46; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R514: 0R / MB3 SD; R_0805_2012Metric
R515: 0R / MB4 TOUCH; R_0805_2012Metric
R516: 0R / MB5 EPD; R_0805_2012Metric
R517, R518, R519, R520, R521, R522: 0R / SD series; R_0603_1608Metric
R523, R524, R525, R526, R527: 10k / SD pull-up; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R528: 10k; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R600: 10k 1% / PG_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1002TCE; LCSC C25744
R601: 100k / P15_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R604: 100k / SD_EN_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R605: 100k / TOUCH_EN_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R606: 100k / EPD_EN_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R607: 100k / BQ_CE_PD; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R608: 100k / FUEL_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R609: 100k / BQ_INT_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R610: 100k / BQ_STAT_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R611: 100k / KEY_FN_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R612: 100k / SD_CD_PU; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF1003TCE; LCSC C25741
R613: 2.2k / I2C_SCL_PU A; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF2201TCE; LCSC C25879
R614: 2.2k / I2C_SDA_PU A; R_0402_1005Metric; Tolerance 1%; Voltage_Rating 50V; MPN 0402WGF2201TCE; LCSC C25879
R903: 100R / CW2217 VDD; R_0603_1608Metric; Tolerance 1%; MPN FRC0603F1000TS; JLCPCB C2906981
R904: 100R / CW2217 VCELL; R_0603_1608Metric; Tolerance 1%; MPN FRC0603F1000TS; JLCPCB C2906981
SW201, SW202: SKSCLCE010; SW_Alps_SKSCLCE010
TP1: VBUS_USB; TestPoint_Pad_D1.5mm
TP2: VSYS_RAW; TestPoint_Pad_D1.5mm
TP3: 3V3_AON; TestPoint_Pad_D1.5mm
TP4: BAT+; TestPoint_Pad_D1.5mm
TP5: 3V3_SD; TestPoint_Pad_D1.5mm
TP6: 3V3_TOUCH; TestPoint_Pad_D1.5mm
TP7: 3V3_EPD_LOGIC; TestPoint_Pad_D1.5mm
TP8: VSYS_AUDIO; TestPoint_Pad_D1.5mm
TP11: I2C_SCL; TestPoint_Pad_D1.5mm
TP12: I2C_SDA; TestPoint_Pad_D1.5mm
TP13: EXP_INT; TestPoint_Pad_D1.5mm
TP14: EXP_INT / SHARED_IRQ; TestPoint_Pad_D1.5mm
TP16: PG_3V3_MAIN; TestPoint_Pad_D1.5mm
TP18: CHIP_PU; TestPoint_Pad_D1.5mm
TPG1, TPG2, TPG3, TPG4, TPG5, TPG6: GND; TestPoint_Pad_D1.5mm
U301: BQ27427YZFR; Texas_DSBGA-9_1.62x1.58mm_Layout3x3_P0.5mm; not fitted
U302: RV-3028-C7; MicroCrystal_C7_SON-8_1.5x3.2mm_P0.9mm
U402, U403, U404, U405: TPS22916CYFPT; TPS22916CYFPT_YFP0004
U501: ESP32-S3-WROOM-1U-N16R8; ESP32-S3-WROOM-1U; MPN ESP32-S3-WROOM-1U-N16R8
U502: MAX98357AETE+T; MAX98357AETE_T_TQFN16
U503: QMI8658A; LGA-14_3x2.5mm_P0.5mm_LayoutBorder3x4y; MPN QMI8658A; LCSC C3021082
U601: XL9535; TCA9535PWR_PW0024A; MPN XL9535; LCSC C561273
U901: SGM41513YTQF24G/TR; SGM41513_YTQF24_4x4_P0.5_EP2.7; MPN SGM41513YTQF24G/TR; LCSC C5153778
U902: SGM62125AXG/TR; SGM62125_XG_WLCSP15_1.46x2.3_P0.4; MPN SGM62125AXG/TR
U903: CW2217BAAD; CW2217BAAD_DFN12_L4.0_W2.5_P0.4_EP; MPN CW2217BAAD; JLCPCB C5203993

Connections:
3V3_AON: C302.1, C501.1, C502.1, C503.1, C504.1, C508.1, C509.1, C511.1, C601.1, J503.2, R303.1, R305.1, R502.2, R509.2, R510.1, R511.1, R528.1, R600.2, R608.2, R609.2, R610.2, R611.2, R612.2, R613.2, R614.2, TP3.1, U302.7 (VDD), U402.A2 (VIN), U403.A2 (VIN), U404.A2 (VIN), U501.2 (3V3), U503.1 (SDO/SA0), U503.5 (Vdd_IO), U503.8 (Vdd), U503.12 (CS), U601.24 (VCC), U901.2 (PSEL)
3V3_AON_SRC: C402.1, C403.1, R509.1, U902.E2 (VOUT), U902.E3 (VOUT)
3V3_EPD_LOGIC: R516.2, TP7.1; also elsewhere on the board
3V3_EPD_LOGIC_SW: R516.1, U404.A1 (VOUT)
3V3_SD: C512.1, C513.1, J501.4 (VDD), R514.2, R523.2, R524.2, R525.2, R526.2, R527.2, TP5.1
3V3_SD_SW: R514.1, U402.A1 (VOUT)
3V3_TOUCH: R515.2, TP6.1
3V3_TOUCH_SW: R515.1, U403.A1 (VOUT)
BAT_CONN_P: J301.1, R306.1, R904.1, TP4.1, U903.8 (CSN)
BAT_PACKP: C206.1, C303.1, R306.2, R903.1, U301.C2 (SRX), U301.C3 (BAT), U901.13 (BAT), U901.14 (BAT), U903.7 (CSP)
BQ_CE: R607.1, U601.9 (P05), U901.9 (nCE)
BQ_ILIM: R201.1, R204.1
BQ_ILIM_RC: C204.1, R204.2
BQ_INT: R609.1, U601.10 (P06), U901.7 (nINT)
BQ_PG: R600.1, U601.13 (P10), U901.3 (nPG)
BQ_QON: SW202.1, U901.12 (nQON)
BQ_STAT: R610.1, U601.11 (P07), U901.4 (STAT)
BQ_TS: U901.11 (TS), U903.9 (TS); also elsewhere on the board
CHIP_PU: C510.1, J503.1, R510.2, TP18.1, U501.3 (EN)
EN_3V3_EPD_LOGIC: R606.1, U404.B2 (ON), U601.6 (P02)
EN_3V3_SD: R604.1, U402.B2 (ON), U601.4 (P00)
EN_3V3_TOUCH: R605.1, U403.B2 (ON), U601.5 (P01)
EN_VSYS_AUDIO: R507.1, U405.B2 (ON), U601.7 (P03)
EPD_CKH: U501.9 (IO16); also elsewhere on the board
EPD_CKV: U501.11 (IO18); also elsewhere on the board
EPD_D0: U501.31 (IO38); also elsewhere on the board
EPD_D1: U501.32 (IO39); also elsewhere on the board
EPD_D2: U501.33 (IO40); also elsewhere on the board
EPD_D3: U501.34 (IO41); also elsewhere on the board
EPD_D4: U501.35 (IO42); also elsewhere on the board
EPD_D5: U501.24 (IO47); also elsewhere on the board
EPD_D6: U501.25 (IO48); also elsewhere on the board
EPD_D7: U501.23 (IO21); also elsewhere on the board
EPD_LE: R512.1, U501.15 (IO3)
EPD_OE: R513.1, U501.16 (IO46)
EPD_STH: U501.26 (IO45); also elsewhere on the board
EPD_STV: U501.10 (IO17); also elsewhere on the board
EXP_INT: R305.2, R502.1, TP13.1, TP14.1, U302.2 (~INT), U501.4 (IO4), U601.1 (~INT)
EXP_P15_SPARE: R601.1, U601.18 (P15)
FUEL_GPOUT: R608.1, U301.A1 (GPOUT), U601.8 (P04), U903.1 (INT_N)
FUEL_VCELL: C903.1, R904.2, U903.4 (VCELL)
FUEL_VDD: C304.1, R903.2, U301.B3 (VDD), U903.3 (VDD)
GAIN_SLOT: R504.1, R505.1, R506.1, U502.2 (GAIN_SLOT)
GND: C202.2, C203.2, C204.2, C205.2, C206.2, C207.2, C208.2, C302.2, C303.2, C304.2, C401.2, C402.2, C403.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C507.2, C508.2, C509.2, C510.2, C511.2, C512.2, C513.2, C601.2, C903.2, J301.2, J501.6 (VSS), J501.10 (DET_A), J501.SH (SHIELD), J503.4, R201.2, R301.2, R302.2, R304.2, R307.2, R501.2, R504.2, R505.2, R507.2, R512.2, R513.2, R601.2, R604.2, R605.2, R606.2, R607.2, SW201.2, SW202.2, TPG1.1, TPG2.1, TPG3.1, TPG4.1, TPG5.1, TPG6.1, U301.B2 (VSS), U301.C1 (VSS), U302.5 (VSS), U402.B1 (GND), U403.B1 (GND), U404.B1 (GND), U405.B1 (GND), U501.1 (GND), U501.40 (GND), U501.41 (GND), U502.3 (GND), U502.11 (GND), U502.15 (GND), U502.17 (EP_THERMAL), U503.2 (SDx), U503.3 (SCx), U503.6 (GND), U503.7 (GND), U601.2 (A1), U601.3 (A2), U601.12 (GND), U601.21 (A0), U901.17 (GND), U901.18 (GND), U901.25 (GND), U902.C1 (AGND), U902.C2 (PGND), U902.C3 (PGND), U903.6 (VSS), U903.13 (PAD); also elsewhere on the board
GPIO0: J503.6, R511.2, U501.27 (IO0)
I2C_SCL: R301.1, R613.1, TP11.1, U301.A3 (SCL), U302.3 (SCL), U501.22 (IO14), U503.13 (SCL), U601.22 (SCL), U901.5 (SCL), U902.D1 (SCL), U903.11 (SCL)
I2C_SDA: R302.1, R614.1, TP12.1, U301.A2 (SDA), U302.4 (SDA), U501.8 (IO15), U503.14 (SDA), U601.23 (SDA), U901.6 (SDA), U902.E1 (SDA), U903.10 (SDA)
I2S_BCLK: U501.19 (IO11), U502.16 (BCLK)
I2S_DIN: U501.21 (IO13), U502.1 (DIN)
I2S_LRCLK: U501.20 (IO12), U502.14 (LRCLK)
IMU_INT1: R501.1, U503.4 (INT1), U601.15 (P12)
KEY_FN: R611.1, U601.14 (P11)
KEY_POWER_MCU: R528.2, SW201.1, U501.39 (IO1)
unnamed: R307.1, U301.B1 (BIN)
PG_3V3_MAIN: TP16.1, U601.17 (P14)
RTC_EVI: R303.2, U302.8 (EVI)
RTC_VBACKUP: R304.1, U302.6 (VBACKUP); also elsewhere on the board
SDMMC_CLK: R517.1, U501.5 (IO5)
SDMMC_CLK_CARD: J501.5 (CLK), R517.2
SDMMC_CMD: R518.1, U501.6 (IO6)
SDMMC_CMD_CARD: J501.3 (CMD), R518.2, R523.1
SDMMC_D0: R519.1, U501.7 (IO7)
SDMMC_D0_CARD: J501.7 (DAT0), R519.2, R524.1
SDMMC_D1: R520.1, U501.12 (IO8)
SDMMC_D1_CARD: J501.8 (DAT1), R520.2, R525.1
SDMMC_D2: R521.1, U501.17 (IO9)
SDMMC_D2_CARD: J501.1 (DAT2), R521.2, R526.1
SDMMC_D3: R522.1, U501.18 (IO10)
SDMMC_D3_CARD: J501.2 (DAT3/CD), R522.2, R527.1
SD_CD: J501.9 (DET_B), R612.1, U601.16 (P13)
SD_MODE: R503.2, U502.4 (SD_MODE)
SGM41513_BTST: C201.1, U901.21 (BTST)
SGM41513_PMID: C203.1, U901.23 (PMID)
SGM41513_REGN: C205.1, U901.22 (REGN); also elsewhere on the board
SGM41513_SW: C201.2, L402.1, U901.19 (SW), U901.20 (SW)
SGM62125_SW1: L401.1, U902.B2 (SW1), U902.B3 (SW1)
SGM62125_SW2: L401.2, U902.D2 (SW2), U902.D3 (SW2)
SPK_N: J502.2, U502.10 (OUTN)
SPK_P: J502.1, U502.9 (OUTP)
UART0_RX: J503.3, U501.36 (RXD0)
UART0_TX: J503.5, U501.37 (TXD0)
USB_DM_MCU: U501.13 (USB_D-); also elsewhere on the board
USB_DP_MCU: U501.14 (USB_D+); also elsewhere on the board
VBUS_USB: C202.1, TP1.1, U901.1 (VAC), U901.24 (VBUS); also elsewhere on the board
VSYS_AUDIO: C505.1, C506.1, R503.1, R506.2, R508.2, TP8.1, U502.7 (VDD), U502.8 (VDD)
VSYS_AUDIO_SW: R508.1, U405.A1 (VOUT)
VSYS_RAW: C207.1, C208.1, C401.1, C507.1, L402.2, TP2.1, U405.A2 (VIN), U901.15 (SYS), U901.16 (SYS), U902.A1 (EN), U902.A2 (VIN), U902.A3 (VIN), U902.B1 (ADDR)

Notes on the sheet:
J501 microSD / SDMMC 4-bit — A-stage, ESD+B-stage+M0+F0+WP9 blocked
供电声明：U405 经已安装 MB6 / R508 = 0R 提供 VSYS_AUDIO（可关断）。 GND 为本板参考地；声明仅补足 ERC 电气模型，未代表实物供电验证。
POWER：双刀瞬时常开，同一机械致动器；松开断开，按下 1-3 / 4-6 闭合。
GPIO1上拉仅接AON；QON保留芯片内部上拉。两信号不可合网。
