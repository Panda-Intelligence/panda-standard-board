# Repository Panda-Intelligence/panda-standard-board (continued)

## KiCad design hardware/pico47/v0.1.2/Single.kicad_pcb (continued)

Schematic: Single-epd2.kicad_sch, 墨水屏电源 SY7636A 与面板、触摸、前光接口（2/2）

Parts:
C809: 1u/50V/0805; C809_Display; MPN 0805B105K500NT; LCSC C215803
C812: 1u/50V/0805; C812_Display; MPN 0805B105K500NT; LCSC C215803
D803: BAV99; D803_Display; MPN BAV99; LCSC C68983
D804: BAV99; D804_Display; MPN BAV99; LCSC C68983
J803: X05A10H06G; J803_Core; MPN X05A10H06G; LCSC C528032
J804: X05A10H06G; J804_Core; MPN X05A10H06G; LCSC C528032
J820: X05A10L40G / E0470A01; J820_Display; MPN X05A10L40G; LCSC C21261162
R810: 100k; R810_Display; MPN RC-02K1003FT; LCSC C140219
R811: 100k; R811_Display; MPN RC-02K1003FT; LCSC C140219
R812: 100k; R812_Display; MPN RC-02K1003FT; LCSC C140219
R910: 10k / TOUCH_INT_PU; R910_Core; Tolerance 0.1%; Voltage_Rating 50V; MPN THC02H1002BT; LCSC C2991528
R911: 10k / TOUCH_RST_PU; R911_Core; Tolerance 0.1%; Voltage_Rating 50V; MPN THC02H1002BT; LCSC C2991528
TP6: 3V3_TOUCH; TP6_Core; MPN NOT_A_PURCHASED_PART
TP7: 3V3_EPD_LOGIC; TP7_Core; MPN NOT_A_PURCHASED_PART
TP801: P47_VGH; TP801_Display; MPN NOT_A_PURCHASED_PART
TP802: P47_VGL; TP802_Display; MPN NOT_A_PURCHASED_PART
TP804: P47_VNEG; TP804_Display; MPN NOT_A_PURCHASED_PART
TP806: P47_BORDER_REVIEW; TP806_Display; MPN NOT_A_PURCHASED_PART

Connections:
3V3_EPD_LOGIC: J820.5, J820.11, J820.34, TP7.1 (1_1); also elsewhere on the board
3V3_TOUCH: J803.2 (VDD3V3), R910.1, R911.1, TP6.1 (1_1); also elsewhere on the board
FL_C_N: J804.5 (SDA); also elsewhere on the board
FL_VOUT: J804.2 (VDD3V3), J804.6 (SCL); also elsewhere on the board
FL_W_N: J804.1 (GND); also elsewhere on the board
GND: C809.2, C812.2, J803.1 (GND), J820.9, J820.12, J820.22, J820.MP, R810.2, R811.2, R812.2; also elsewhere on the board
I2C_SCL: J803.6 (SCL); also elsewhere on the board
I2C_SDA: J803.5 (SDA); also elsewhere on the board
P47_BORDER_REVIEW: J820.40, TP806.1
P47_CKV: J820.7; also elsewhere on the board
P47_D0: J820.14; also elsewhere on the board
P47_D1: J820.15; also elsewhere on the board
P47_D2: J820.16; also elsewhere on the board
P47_D3: J820.17; also elsewhere on the board
P47_D4: J820.18; also elsewhere on the board
P47_D5: J820.19; also elsewhere on the board
P47_D6: J820.20; also elsewhere on the board
P47_D7: J820.21; also elsewhere on the board
P47_D8: J820.23; also elsewhere on the board
P47_D9: J820.24; also elsewhere on the board
P47_D10: J820.25; also elsewhere on the board
P47_D11: J820.26; also elsewhere on the board
P47_D12: J820.27; also elsewhere on the board
P47_D13: J820.28; also elsewhere on the board
P47_D14: J820.29; also elsewhere on the board
P47_D15: J820.30; also elsewhere on the board
P47_MODE: J820.6, R810.1; also elsewhere on the board
P47_PUMP_NEG: D804.3 (K1_A2); also elsewhere on the board
P47_PUMP_POS: D803.3 (K1_A2); also elsewhere on the board
P47_SPV: J820.8; also elsewhere on the board
P47_VCOM: J820.10; also elsewhere on the board
P47_VEE_BASE: D804.2 (K2); also elsewhere on the board
P47_VGH: C809.1, D803.2 (K2), J820.3, TP801.1; also elsewhere on the board
P47_VGH_BASE: D803.1 (A1); also elsewhere on the board
P47_VGL: C812.1, D804.1 (A1), J820.1, R812.1, TP802.1; also elsewhere on the board
P47_VNEG: J820.38, TP804.1; also elsewhere on the board
P47_VPOS: J820.36; also elsewhere on the board
P47_XCL: J820.13; also elsewhere on the board
P47_XLE: J820.32; also elsewhere on the board
P47_XOE: J820.33, R811.1; also elsewhere on the board
P47_XSTL: J820.31; also elsewhere on the board
TOUCH_INT: J803.4 (INT), R910.2
TOUCH_RST: J803.3 (RST), R911.2; also elsewhere on the board

Notes on the sheet:
墨水屏电源 SY7636A 与面板、触摸、前光接口（2/2）

Schematic: Single-power1.kicad_sch, 充电、3V3 升降压、电量计、音频与前光驱动（1/2）

Parts:
C201: 47n / CBOOT; C201_Core; MPN 0603B473K500NT; LCSC C285123
C203: 10u / PMID; C203_Core; MPN 1206B106K250NT; LCSC C90538
C205: 4.7u / REGN; C205_Core; MPN 0805B475K160NT; LCSC C880382
C206: 10u / BAT; C206_Core; MPN 0805B106K100NT; LCSC C90544
C207: 22u / CSYS1; C207_Core; MPN 0805X226M250NT; LCSC C129303
C208: 22u / CSYS2; C208_Core; MPN 0805X226M250NT; LCSC C129303
C303: 1u / BQ BAT; C303_Core; MPN 0402B105K100NT; LCSC C1526
C304: 2.2u / BQ VDD; C304_Core; MPN TCC0402X5R225M100AT; LCSC C18164608
C402: 22u / VOUT; C402_Core; MPN 0603X226M100NT; LCSC C60077
C403: 22u / VOUT; C403_Core; MPN 0603X226M100NT; LCSC C60077
C505: 100n / AUDIO_VDD; C505_Core; MPN 0402B104K250NT; LCSC C56392
C506: 10u / AUDIO_VDD; C506_Core; MPN CGA0603X7R106K100JT; LCSC C22399626
C903: 1u / CW2217 VCELL; C903_Core; Voltage_Rating 25V; MPN 0603B105K250NT; LCSC C59302
C920: 4.7uF 16V X7R / FL_CIN; C920_Core; Tolerance 10%; Voltage_Rating 16V; MPN 0805B475K160NT; LCSC C880382
C921: 1uF 10V X7R / FL_VIN; C921_Core; Tolerance 10%; Voltage_Rating 10V; MPN 0402B105K100NT; LCSC C1526
C922: 1uF 10V X7R / FL_VDC; C922_Core; Tolerance 10%; Voltage_Rating 10V; MPN 0402B105K100NT; LCSC C1526
C923: 4.7uF 50V X7R / FL_COUT; C923_Core; Tolerance 10%; Voltage_Rating 50V; MPN 1206B475K500NT; LCSC C29823
D905: B5819W SL / FL_RECT; D905_Core; Voltage_Rating 40V; MPN B5819W SL; LCSC C8598
L401: 0.47uH / SGM62125; L401_Core; MPN MWSA0402S-R47MT; LCSC C6331050
L402: 1uH / SGM41513 buck; L402_Core; MPN MWSA0402S-1R0MT; LCSC C408332
L905: 10uH / FL_BOOST; L905_Core; Tolerance 20%; MPN SWPA252012S100MT; LCSC C37428
R201: 5.6k / PSEL low leg; R201_Core; MPN RS-03K5601FT; LCSC C99891
R204: 1.2k / REGN to PSEL; R204_Core; MPN RS-03K1201FT; LCSC C118396
R509: 0R / MB2 3V3_AON; R509_Core; MPN RS-05000FT; LCSC C132364
R601: 100k / FL_HWEN_PD; R601_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R615: 5.23k; R615_Core; MPN RS-03K5231FT; LCSC C140082
R616: 30.1k; R616_Core; MPN RS-03K3012FT; LCSC C321843
R903: 100R / CW2217 VDD; R903_Core; Tolerance 1%; MPN FRC0603F1000TS; LCSC C2906981
R904: 100R / CW2217 VCELL; R904_Core; Tolerance 1%; MPN FRC0603F1000TS; LCSC C2906981
R920: 10R 1% / FL_VIN_RC; R920_Core; Tolerance 1%; Voltage_Rating 50V; MPN RS-03K10R0FT; LCSC C136596
R922: 100k / FL_PWM_PD; R922_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R931: 1.2k / hardware permit; R931_Core; MPN RS-03K1201FT; LCSC C118396
SW202: TS-1186E-B-B; SW202_Core; MPN TS-1186E-B-B; LCSC C2885153
TP1: VBUS_USB; TP1_Core; MPN NOT_A_PURCHASED_PART
TP2: VSYS_RAW; TP2_Core; MPN NOT_A_PURCHASED_PART
TP4: BAT+; TP4_Core; MPN NOT_A_PURCHASED_PART
TP8: VSYS_AUDIO; TP8_Core; MPN NOT_A_PURCHASED_PART
TP11: I2C_SCL; TP11_Core; MPN NOT_A_PURCHASED_PART
TP12: I2C_SDA; TP12_Core; MPN NOT_A_PURCHASED_PART
TPG2: GND; TPG2_Core; MPN NOT_A_PURCHASED_PART
TPG3: GND; TPG3_Core; MPN NOT_A_PURCHASED_PART
U901: SGM41513YTQF24G/TR; U901_Core; MPN SGM41513YTQF24G/TR; LCSC C5153778
U902: SGM62125AXG/TR; U902_Core; MPN SGM62125AXG/TR
U903: CW2217BAAD; U903_Core; MPN CW2217BAAD; LCSC C5203993
U904: NS4168; U904_Core; MPN NS4168; LCSC C910588
U905: SGM37601YTRL20G/TR; U905_Core; MPN SGM37601YTRL20G/TR

Connections:
3V3_AON: R509.2; also elsewhere on the board
3V3_AON_SRC: C402.1, C403.1, R509.1, U902.E2 (VOUT_E2), U902.E3 (VOUT_E3)
BAT_CONN_P: R904.1, TP4.1 (1_1), U903.8 (CSN); also elsewhere on the board
BAT_PACKP: C206.1, C303.1, R903.1, U901.13 (BAT), U901.14 (BAT), U903.7 (CSP); also elsewhere on the board
BQ_INT: U901.7 (nINT); also elsewhere on the board
BQ_PG: U901.3 (nPG); also elsewhere on the board
BQ_QON: SW202.1, U901.12 (nQON)
BQ_STAT: U901.4 (STAT); also elsewhere on the board
BQ_TS: R615.2, R616.1, U901.11 (TS), U903.9 (TS); also elsewhere on the board
CHG_nCE: U901.9 (nCE); also elsewhere on the board
FL_C_N: U905.11 (LED2); also elsewhere on the board
FL_HWEN: R601.1, R931.2, U905.19 (EN); also elsewhere on the board
FL_PWM: R922.1, U905.20 (PWM); also elsewhere on the board
FL_SW: D905.2 (A), L905.2, U905.16 (SW), U905.17 (SW)
FL_VDC: C922.1, U905.3 (VDC)
FL_VIN: C921.1, R920.2, U905.18 (VIN)
FL_VOUT: C923.1, D905.1 (K), U905.14 (VOUT); also elsewhere on the board
FL_W_N: U905.12 (LED1); also elsewhere on the board
FUEL_GPOUT: U903.1 (INT_N); also elsewhere on the board
FUEL_VCELL: C903.1, R904.2, U903.4 (VCELL)
FUEL_VDD: C304.1, R903.2, U903.3 (VDD)
GND: C203.2, C205.2, C206.2, C207.2, C208.2, C303.2, C304.2, C402.2, C403.2, C505.2, C506.2, C903.2, C920.2, C921.2, C922.2, C923.2, R201.2, R601.2, R616.2, R922.2, SW202.2, TPG2.1 (1_1), TPG3.1 (1_1), U901.17 (GND), U901.18 (GND), U901.25 (GND), U902.C1 (AGND_C1), U902.C2 (PGND_C2), U902.C3 (PGND_C3), U903.6 (VSS), U903.13 (PAD), U904.7 (GND), U904.9 (EP), U905.5 (A0), U905.9 (AGND), U905.15 (PGND), U905.21 (AGND_EP); also elsewhere on the board
HW_ARM_GPIO: R931.1; also elsewhere on the board
I2C_SCL: TP11.1 (1_1), U901.5 (SCL), U902.D1 (SCL_D1), U903.11 (SCL), U905.2 (SCL); also elsewhere on the board
I2C_SDA: TP12.1 (1_1), U901.6 (SDA), U902.E1 (SDA_E1), U903.10 (SDA), U905.1 (SDA); also elsewhere on the board
I2S_BCLK: U904.3 (BCLK); also elsewhere on the board
I2S_DIN: U904.4 (SDATA); also elsewhere on the board
I2S_LRCLK: U904.2 (LRCLK); also elsewhere on the board
SGM41513_BTST: C201.1, U901.21 (BTST)
SGM41513_PMID: C203.1, U901.23 (PMID)
SGM41513_PSEL: R201.1, R204.1, U901.2 (PSEL)
SGM41513_REGN: C205.1, R204.2, R615.1, U901.22 (REGN); also elsewhere on the board
SGM41513_SW: C201.2, L402.1, U901.19 (SW), U901.20 (SW)
SGM62125_SW1: L401.1, U902.B2 (SW1_B2), U902.B3 (SW1_B3)
SGM62125_SW2: L401.2, U902.D2 (SW2_D2), U902.D3 (SW2_D3)
SPK_N: U904.5 (VON); also elsewhere on the board
SPK_P: U904.8 (VOP); also elsewhere on the board
VBUS_USB: TP1.1 (1_1), U901.1 (VAC), U901.24 (VBUS); also elsewhere on the board
VSYS_AUDIO: C505.1, C506.1, TP8.1 (1_1), U904.1 (CTRL), U904.6 (VDD); also elsewhere on the board
VSYS_RAW: C207.1, C208.1, C920.1, L402.2, L905.1, R920.1, TP2.1 (1_1), U901.15 (SYS), U901.16 (SYS), U902.A1 (EN_A1), U902.A2 (VIN_A2), U902.A3 (VIN_A3), U902.B1 (ADDR_B1); also elsewhere on the board

Notes on the sheet:
充电、3V3 升降压、电量计、音频与前光驱动（1/2）

Schematic: Single-power2.kicad_sch, 充电、3V3 升降压、电量计、音频与前光驱动（2/2）

Parts:
C940: 100n / XB7608A; C940_Core; MPN 0402B104K250NT; LCSC C56392
Q907: NX3008NBK,215-JSM; Q907_Core; MPN NX3008NBK,215-JSM; LCSC C53113911
Q908: NX3008NBK,215-JSM; Q908_Core; MPN NX3008NBK,215-JSM; LCSC C53113911
R930: 100k / nCE default OFF; R930_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R932: 10k / gate default LOW; R932_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R933: 10k / gate default LOW; R933_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R940: 1k / XB7608A VDD; R940_Core; MPN RC-02K1001FT; LCSC C140197
TP19: HW_ARM / FORCE LOW; TP19_Core; MPN NOT_A_PURCHASED_PART
TPG4: GND; TPG4_Core; MPN NOT_A_PURCHASED_PART
TPG5: GND; TPG5_Core; MPN NOT_A_PURCHASED_PART
U906: SGM809B-TXN3LG/TR; U906_Core; MPN SGM809B-TXN3LG/TR; LCSC C699619
U907: XB7608A / CELL PROTECTION; U907_Core; MPN XB7608A; LCSC C669688

Connections:
3V3_AON: U906.3 (VCC); also elsewhere on the board
BAT_CELL_N: C940.2, U907.2 (GND), U907.3 (GND); also elsewhere on the board
BAT_CONN_P: R940.1; also elsewhere on the board
BAT_PROT_VDD: C940.1, R940.2, U907.1 (VDD)
CHG_REQUEST: Q907.1 (G), R932.1; also elsewhere on the board
CHG_RETURN: Q907.3 (S), Q908.2 (D)
CHG_nCE: Q907.2 (D), R930.1; also elsewhere on the board
FL_HWEN: Q908.1 (G), R933.1, TP19.1 (1_1); also elsewhere on the board
GND: Q908.3 (S), R932.2, R933.2, TPG4.1 (1_1), TPG5.1 (1_1), U906.1 (GND), U907.4 (VM), U907.5 (VM); also elsewhere on the board
PG_3V3_MAIN: U906.2 (nRESET); also elsewhere on the board
SGM41513_REGN: R930.2; also elsewhere on the board

Notes on the sheet:
充电、3V3 升降压、电量计、音频与前光驱动（2/2）

Board: 4 copper layers, 71.0 x 99.0 mm, 265 parts (9 on the bottom side), 185 nets.

## Code that names these connections

File hardware/pico47/build_pico47.py (part):

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    for g,p in [(33,38),(34,39),(35,40),(36,41),(37,42)]:
        host['pins'][str(p)]={'name':'GPIO'+str(g)+'_RESERVED_OCTAL_PSRAM','type':'no_connect'}
        host['nets'][str(p)]=''
    host['fields']['Description']='E0 bare-chip pin map: physical36=GPIO48,37=GPIO47. All33 usableGPIO allocated. KeepGPIO33..37 reserved,GPIO2 direct inhibit,GPIO19/20USB. Incompatible with D firmware.'
    # R25 reset ECO: keep the ESP32 EN input local and isolate the debug
    # connector with a reviewed 1 kOhm series link. R529 is already the USB
    # DP series part in the donor, so the new link uses the unused R533 ref.
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    for ref,oldnet,newnet in [('R512','EPD_LE','P47_D8_SRC'),('R513','EPD_OE','P47_BUS_SELECT')]:
        require(core[ref]['nets']['1']==oldnet,'Unexpected strap predecessor')
        core[ref]['nets']['1']=newnet;core[ref]['fields']['Description']='E0 explicit10k strap pulldown for '+newnet
    core['U601']['nets']['18']='P47_BUS_OE_N';core['U601']['pins']['18']={'name':'P15','type':'bidirectional'}
    for ref,count in [('J601','40'),('J602','20')]:
        core[ref]['nets']={**plan['interconnect'][count],'MP':'GND'}
        core[ref]['pins']={n:{'name':n,'type':'passive'} for n in core[ref]['nets']}
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        core[ref]['fields']['PandaModuleCompatibility']='E0 TOUCH/FRONTLIGHT ASSEMBLY PINOUT AND CONTACT SIDE UNCONFIRMED;NOT VERIFIED BY OLD FT01C DRAWING'
    muxpin={'1':('IN','input'),'8':('GND','power_in'),'15':('EN_N','input'),'16':('VCC','power_in')}
    for idx,ref in enumerate(['U710','U711']):
        ns={'1':'P47_BUS_SELECT','8':'GND','15':'P47_BUS_OE_N','16':'3V3_AON'};pi={p:{'name':n,'type':t} for p,(n,t) in muxpin.items()}
        for item,(a,b,common) in zip(plan['mux']['channels'][idx*4:idx*4+4],plan['mux']['source_terminal_pins']):
            for p,n,nm in [(a,item['select_0_net'],'S1'),(b,item['select_1_net'],'S2'),(common,item['common_net'],'D')]:
                ns[str(p)]=n;pi[str(p)]={'name':nm+str(item['channel']%4),'type':'passive'}
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        note='Source-table exact pin map;TP/NC float. Exposed pad must NOT connect GND.2020 reference requires current manufacturer recheck; not authorized for power-on.')
    # AuxiliaryGPIO: address0x21; first legacy expander remains0x20.
    exp=copy.deepcopy(old['Core'][0]['U601']);ex={str(i):'' for i in range(1,25)}
    ex.update({'1':'EXP_INT','2':'GND','3':'GND','4':'P47_HV_EN','5':'P47_VCOM_EN','6':'P47_MODE','7':'P47_XOE','12':'GND','13':'P47_PGOOD','14':'HW_ARM_GPIO','21':'3V3_AON','22':'I2C_SCL','23':'I2C_SDA','24':'3V3_AON'})
    epi=copy.deepcopy(exp['pins'])
    for p in ex:
        epi.setdefault(p,{'name':p,'type':'bidirectional'})
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    for ref,a,b in [('L801','VSYS_RAW','P47_VP_LX'),('L802','P47_VN_LX','GND')]:
        new('Display',ref,'4.7uH / MWSA0618S-4R7MT',('Display','INDUCT_TEMPLATE'),{'1':a,'2':b},'Sunlord',induct['mpn'],induct['catalog_code'],induct['source_url'],
            note='Manufacturer DCR62mOhm max,height1.8mm max; Isat columns Max/Typ4/5A and Irms3.5/4A. Do NOT rename a Max column as a guaranteed minimum. Startup/hot/short-circuit margin remains unqualified.')
    resistor('Display','R813','1k','HW_ARM_GPIO','P47_HV_EN')
    for ref,a,k in [('D801','P47_VP_LX','P47_VP'),('D802','P47_VN','P47_VN_LX')]:
        new('Display',ref,'MBR0530 / PEAK REVIEW',('Display','D1'),{'1':k,'2':a},'JSCJ','MBR0530','C77336',old['Display'][0]['D1']['datasheet'],
             {'1':{'name':'K','type':'passive'},'2':{'name':'A','type':'passive'}},note='Engineering0.5A/30V Schottky selection; surge/current-loss review pending.')
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
File hardware/pico47/pico47_contract.py (part):

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]

EXPECTED_NETS = {
    0: 'GPIO0', 1: 'KEY_POWER_MCU', 2: 'HW_ARM_GPIO', 3: 'P47_D8_SRC',
    4: 'EXP_INT', 5: 'P47_MUX6', 6: 'P47_MUX7', 7: 'P47_MUX4',
    8: 'P47_MUX0', 9: 'P47_MUX1', 10: 'P47_MUX2', 11: 'P47_D13_SRC',
    12: 'P47_CKV_SRC', 13: 'P47_XLE_SRC', 14: 'P47_XCL_SRC', 15: 'I2C_SDA',
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    47: 'P47_D12_SRC', 48: 'P47_SPV_SRC',
}
EXPECTED_MUX_CHANNELS = [
    {'channel': 0, 'gpio': 8, 'package_pin': 13, 'common_net': 'P47_MUX0',
     'select_0_net': 'SDMMC_D0', 'select_1_net': 'P47_D0_SRC'},
    {'channel': 1, 'gpio': 9, 'package_pin': 14, 'common_net': 'P47_MUX1',
     'select_0_net': 'SDMMC_D1', 'select_1_net': 'P47_D2_SRC'},
    {'channel': 2, 'gpio': 43, 'package_pin': 49, 'common_net': 'P47_MUX5',
     'select_0_net': 'UART0_TX', 'select_1_net': 'P47_D3_SRC'},
    {'channel': 3, 'gpio': 44, 'package_pin': 50, 'common_net': 'P47_MUX3',
     'select_0_net': 'UART0_RX', 'select_1_net': 'P47_D1_SRC'},
    {'channel': 4, 'gpio': 7, 'package_pin': 12, 'common_net': 'P47_MUX4',
     'select_0_net': 'SDMMC_CLK', 'select_1_net': 'P47_D5_SRC'},
    {'channel': 5, 'gpio': 10, 'package_pin': 15, 'common_net': 'P47_MUX2',
     'select_0_net': 'SDMMC_D3', 'select_1_net': 'P47_D6_SRC'},
    {'channel': 6, 'gpio': 5, 'package_pin': 10, 'common_net': 'P47_MUX6',
     'select_0_net': 'SDMMC_CMD', 'select_1_net': 'P47_D4_SRC'},
    {'channel': 7, 'gpio': 6, 'package_pin': 11, 'common_net': 'P47_MUX7',
     'select_0_net': 'SDMMC_D2', 'select_1_net': 'P47_D7_SRC'},
]

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EXPECTED_INTER20 = {str(i+1): n for i, n in enumerate([
    'VSYS_RAW', 'VSYS_RAW', 'GND', 'GND', '3V3_AON', '3V3_AON', 'GND', 'GND',
    '3V3_EPD_LOGIC', '3V3_EPD_LOGIC', 'GND', 'GND', 'I2C_SCL', 'I2C_SDA',
    'EXP_INT', 'HW_ARM_GPIO', 'P47_PGOOD', 'GND', 'GND', 'GND',
])}

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    for i in range(16):
        require(inter['40'][str(2*i+1)] == 'P47_D' + str(i)
                and inter['40'][str(2*i+2)] == 'GND', 'Data return missing')
    require(inter['20']['16'] == 'HW_ARM_GPIO'
            and inter['20']['17'] == 'P47_PGOOD'
            and inter['new_pinout_incompatible_with_D'] is True, 'Wrong FFC revision')
    pm = p['pmic']
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            and pm['reference_default_vgh_25v_prohibited'] is True, 'Wrong VGH')
    require(pm['vgl_target_v'] == -20 and pm['source_rails_v'] == [15, -15], 'Wrong rails')
    en = pm['direct_enable']
    require(en['source_gpio'] == 2 and en['source_net'] == 'HW_ARM_GPIO'
            and en['series_resistor_ref'] == 'R813' and en['series_ohm'] == 1000
            and en['pmic_enable_net'] == 'P47_HV_EN'
            and en['enable_pulldown_ohm'] == 100000, 'Direct inhibit path changed')
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
File hardware/pico47/build_pico47_single.py (part):

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    p_vgl_diode = pin(diode, '1')
    require(c1.GetNetname() == p_ic.GetNetname() == p_diode.GetNetname() == contract['power_net']
            and c2.GetNetname() == p_gnd.GetNetname() == 'GND',
            'P47_VEE_BASE pin net differs')
    require(p_drv_ic.GetNetname() == p_drv_cap.GetNetname() == contract['joint_driver_net'],
            'P47_VEE_DRV pin net differs')
    require(p_vgl_sense.GetNetname() == p_vgl_diode.GetNetname() == contract['joint_vgl_net'],
            'P47_VGL pin net differs')
    group_for = {u: g for g in (groups if groups is not None else pad_components(board)) for u in g}
    for x, y in [(c1, p_ic), (c1, p_diode), (c2, p_gnd), (p_drv_cap, p_drv_ic), (p_vgl_sense, p_vgl_diode)]:
        require(y.m_Uuid.AsString() in group_for[x.m_Uuid.AsString()],
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        p_vgh_diode = pin(pos_diode, '2')
        require(pc1.GetNetname() == p_pos_ic.GetNetname() == p_pos_diode.GetNetname() == pos['power_net']
                and pc2.GetNetname() == p_gnd.GetNetname() == 'GND',
                'P47_VGH_BASE pin net differs')
        require(p_pos_drv_ic.GetNetname() == p_pos_drv_cap.GetNetname() == pos['joint_driver_net'],
                'P47_VGH_DRV pin net differs')
        require(p_vgh_sense.GetNetname() == p_vgh_diode.GetNetname() == pos['joint_vgh_net'],
                'P47_VGH pin net differs')
        for x, y in [(pc1, p_pos_ic), (pc1, p_pos_diode), (pc2, p_gnd), (p_pos_drv_cap, p_pos_drv_ic), (p_vgh_sense, p_vgh_diode)]:
            require(y.m_Uuid.AsString() in group_for[x.m_Uuid.AsString()],
                    'PMIC positive charge-pump scope has no actual copper connection')
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                                   ((2, 3, 4), (5, 6, 7), (11, 10, 9), (14, 13, 12))):
            for pin, key in zip(triple, ('select_0_net', 'select_1_net', 'common_net')):
                expect(ref, pin, channel[key])
        for pin, net in {1:'P47_BUS_SELECT', 8:'GND', 15:'P47_BUS_OE_N', 16:'3V3_AON'}.items():
            expect(ref, pin, net)
    require(fps['U501'].GetValue() == 'ESP32-S3R8', 'Wrong MCU memory variant')
    require(fps['U506'].GetValue() == 'GD25Q128ESIG', 'Wrong 16MB flash')
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
File hardware/thin18-compact/verify_split_c1_hardware_finish.py:

#!/usr/bin/env python3
"""Independent native hardware-inhibit contract; topology is not a bench result."""
import argparse,copy,json,re
from pathlib import Path
from _split_c1_common import ROOT,REPO,REL,STEM,repo_entry
from _split_c1_sourcing import blocks,property_value
from verify_split_c1_power_integrity import parse_netlist,check
PINS={
 'Q907':{'1':'CHG_REQUEST','2':'CHG_nCE','3':'CHG_RETURN'},
 'Q908':{'1':'FL_HWEN','2':'CHG_RETURN','3':'GND'},
 'R930':{'1':'CHG_nCE','2':'SGM41513_REGN'},
 'R931':{'1':'HW_ARM_GPIO','2':'FL_HWEN'},
 'R932':{'1':'CHG_REQUEST','2':'GND'},'R933':{'1':'FL_HWEN','2':'GND'},
 'TP19':{'1':'FL_HWEN'},'R607':{'1':'CHG_REQUEST','2':'GND'},'R601':{'1':'FL_HWEN','2':'GND'},
}
IDENTITIES={
 'Q907':('JSMSEMI','NX3008NBK,215-JSM','C53113911'),
 'Q908':('JSMSEMI','NX3008NBK,215-JSM','C53113911'),
 'R930':('FH (Fenghua Advanced)','RC-02K1003FT','C140219'),
 'R931':('FH (Fenghua Advanced)','RS-03K1201FT','C118396'),
 'R932':('FH (Fenghua Advanced)','RC-02K1002FT','C140215'),
 'R933':('FH (Fenghua Advanced)','RC-02K1002FT','C140215'),
}

def verify(fields,pins,nets):
 for ref,expected in IDENTITIES.items():
  check(tuple(fields.get(ref,{}).get(k,'') for k in ['Manufacturer','MPN','LCSC'])==expected,'Wrong inhibit part '+ref)
 for ref,mapping in PINS.items():
  check({p:n for (r,p),n in pins.items() if r==ref}==mapping,'Wrong inhibit pin map '+ref)
 check(pins.get(('U901','9'))=='CHG_nCE','Charger nCE not isolated')
 check(pins.get(('U601','9'))=='CHG_REQUEST','Expander request polarity/net differs')
 check(pins.get(('U601','18'),'').startswith('unconnected-'),'P15 must not drive direct permit')
 check(pins.get(('U501','38'))=='HW_ARM_GPIO','Direct permit must use module GPIO2/pad38')
 check(pins.get(('U905','19'))=='FL_HWEN','Frontlight hardware EN not directly inhibited')
 check(nets.get('CHG_nCE')=={('U901','9'),('R930','1'),('Q907','2')},'Unexpected nCE driver/backfeed')
 check(nets.get('CHG_RETURN')=={('Q907','3'),('Q908','2')},'Series authorization bypassed')
 check(nets.get('CHG_REQUEST')=={('U601','9'),('R607','1'),('R932','1'),('Q907','1')},'Unexpected charge-request driver')
 check(nets.get('HW_ARM_GPIO')=={('U501','38'),('R931','1')},'Direct GPIO bypasses limiting resistor')
 check(nets.get('FL_HWEN')=={('R931','2'),('R601','1'),('R933','1'),('Q908','1'),('TP19','1'),('U905','19')},'Unexpected hardware-permit connection')
 check('BQ_CE' not in nets,'Obsolete active-low expander net remains')
 return True

def negative_controls(fields,pins,nets):
 cases=[]
 for ref,p in [('Q907','2'),('Q908','2'),('R930','2'),('R932','2'),('R933','2'),('R931','1'),('U501','38'),('U901','9'),('U601','18'),('U905','19')]:
  bad=pins.copy();bad[(ref,p)]='UNREVIEWED_NET';cases.append((fields,bad,nets))
 for ref in IDENTITIES:
  bad=copy.deepcopy(fields);bad[ref]['MPN']='LOOKALIKE';cases.append((bad,pins,nets))
 for net in ['CHG_nCE','CHG_RETURN','CHG_REQUEST','HW_ARM_GPIO','FL_HWEN']:
  bad=copy.deepcopy(nets);bad[net].add(('UNREVIEWED_DRIVER','1'));cases.append((fields,pins,bad))
 for args in cases:
  try:verify(*args)
  except ValueError:continue
  raise AssertionError('Bad inhibit fixture accepted')
 return len(cases)

def inspect(candidate,netlist):
 candidate=Path(candidate);pcb=candidate/REL/(STEM+'.kicad_pcb')
 fields,pins,nets=parse_netlist(netlist);verify(fields,pins,nets)
 fps={property_value(f,'Reference'):f for _,_,f in blocks(pcb.read_text(),r'\(footprint\s')}
 for ref,mapping in PINS.items():
  f=fps[ref];check('(dnp yes)' not in f,'Required inhibit part DNP')
  padnets={}
  for _,_,p in blocks(f,r'\(pad\s'):
   n=re.match(r'\(pad\s+"([^\"]*)"',p).group(1);net=re.search(r'\(net\s+"([^\"]+)"',p)
   if n and net:padnets[n]=net.group(1)
  check(padnets==mapping,'PCB inhibit connectivity differs '+ref)
  if ref in IDENTITIES:check(tuple(property_value(f,k) for k in ['Manufacturer','MPN','LCSC'])==IDENTITIES[ref],'PCB inhibit identity differs')
  if ref in ['Q907','Q908']:
   for _,_,p in blocks(f,r'\(pad\s'):
    n=re.match(r'\(pad\s+"([^\"]+)"',p).group(1)
    xy=tuple(map(float,re.search(r'\(at\s+([-\d.]+)\s+([-\d.]+)',p).groups()))
    size=tuple(map(float,re.search(r'\(size\s+([-\d.]+)\s+([-\d.]+)',p).groups()))
    check(xy=={'1':(-1.01,-.95),'2':(-1.01,.95),'3':(1.01,0)}[n] and size==(.8,.6),'Wrong original-maker MOS lands/pins')
 # Truth table is an electrical topology model, not an analog measurement.
 truth=[{'request':a,'permit':b,'nCE_sink_allowed':bool(a and b),'frontlight_EN':bool(b)} for a in [0,1] for b in [0,1]]
 return {'schema':'panda-split-c1-hardware-finish-verification-v1','inputs':{'pcb':repo_entry(pcb),'schematic':repo_entry(pcb.with_suffix('.kicad_sch')),'checker':repo_entry(Path(__file__)),'contract':repo_entry(ROOT/'split-c1-hardware-finish.json')},
 'default_off_topology_passed':True,'non_i2c_shutdown_path_present':True,'new_exact_identities_verified':len(IDENTITIES),
 'mos_pin_land_check_passed':True,'negative_cases_rejected':negative_controls(fields,pins,nets),'truth_table':truth,
 'physical_ramp_and_shutdown_tested':False,'independent_autonomous_watchdog_present':False,'manufacturing_release':False}

def main():
 p=argparse.ArgumentParser();p.add_argument('--candidate',type=Path,default=ROOT/'core-c1-96x68-split');p.add_argument('--netlist',type=Path);p.add_argument('--output',type=Path,default=ROOT/'split-c1-hardware-finish-verification.json');a=p.parse_args()
 report=inspect(a.candidate,a.netlist or a.candidate/'verification/netlist.xml');a.output.write_text(json.dumps(report,indent=2)+'\n')
 print(json.dumps({k:v for k,v in report.items() if k!='inputs'},indent=2))
if __name__=='__main__':main()

File hardware/pico47/r25_router/pinswap_opt.py (part):

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
Free choices (all firmware-remappable through the ESP32-S3 GPIO matrix):
  * which SD/UART signal and which display data bit share each of the 8 SGM330A channels;
  * which of GPIO5..10 drives each SD channel common (UART TX/RX commons stay on GPIO43/44);
  * which 8 data bits are direct, and which direct GPIO (3,14,17,18,21,38,39,40) drives each.
Fixed: strapping roles, USB, I2C, I2S, controls, panel bit -> R7xx -> FFC.
usage: pinswap_opt.py geom.json spec.json design.json out.json
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SD_SIGNALS = {'SDMMC_D0': ('R519', '1'), 'SDMMC_D1': ('R520', '1'), 'SDMMC_D2': ('R521', '1'),
              'SDMMC_D3': ('R522', '1'), 'SDMMC_CLK': ('R517', '1'), 'SDMMC_CMD': ('R518', '1'),
              'UART0_TX': ('J503', '5'), 'UART0_RX': ('J503', '3')}
UART_GPIO = {'UART0_TX': 43, 'UART0_RX': 44}
SD_GPIOS = [5, 6, 7, 8, 9, 10]
# GPIO3 (strapping) keeps data bit 8 together with its R512 network; it is outside the swap pool
DIRECT_GPIOS = [14, 17, 18, 21, 38, 39, 40]
BITS = [b for b in range(16) if b != 8]
bit_pad = {k: ('R' + str(710 + k), '1') for k in BITS}
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
def normalise(sd, gp):
    """UART channels must use GPIO43/44; SD channels use GPIO5..10 in the given order list."""
    order = [x for x in gp if x in SD_GPIOS]
    it = iter(order)
    return [UART_GPIO[s] if s in UART_GPIO else next(it) for s in sd]
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
File hardware/pico47/v024/layout/eco_gpio0.py:

"""eco_gpio0.py in out fp_dir: FL_PWM moves from GPIO0 (U501 pin 5) to GPIO2 (pin 7); I2S_BCLK takes GPIO0.
R511 (boot pull-up) and TP19 stay on GPIO0, now I2S_BCLK. New R515 100k pulls FL_PWM down. All copper of the two
nets is removed here; the grid router lays both again (layout/spec_gpio0.json)."""
import sys, pcbnew as P
MM = P.FromMM
b = P.LoadBoard(sys.argv[1]); KEEP = []
for t in list(b.GetTracks()):
    if t.GetNetname() in ('FL_PWM', 'I2S_BCLK'): b.Remove(t); KEEP.append(t)
def setnet(ref, num, net):
    p = next(p for p in b.FindFootprintByReference(ref).Pads() if p.GetNumber() == num); p.SetNet(b.FindNet(net))
setnet('U501', '5', 'I2S_BCLK'); setnet('U501', '7', 'FL_PWM'); setnet('R511', '2', 'I2S_BCLK'); setnet('TP19', '1', 'I2S_BCLK')
f = P.FootprintLoad(sys.argv[3], 'R_0402_1005Metric'); f.SetReference('R515'); f.SetValue('100k / FL_PWM_PD'); b.Add(f)
f.SetFPID(P.LIB_ID('Panda47v2', 'R_0402_1005Metric')); f.SetPosition(P.VECTOR2I(MM(35.8), MM(71.0))); f.SetOrientationDegrees(0)
for p in f.Pads(): p.SetNet(b.FindNet({'1': 'FL_PWM', '2': 'GND'}[p.GetNumber()]))
f.Reference().SetVisible(False); f.Value().SetVisible(False)
P.ZONE_FILLER(b).Fill(b.Zones()); b.Save(sys.argv[2])
