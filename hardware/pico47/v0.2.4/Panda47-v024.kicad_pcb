# Repository Panda-Intelligence/panda-standard-board (continued)

## KiCad design hardware/pico47/v0.2.4/Panda47-v024.kicad_pcb (continued)

Parts:
C801, C803: 10u/25V/0603; C_0603_1608Metric; MPN CL10A106MA8NRNC; LCSC C96446
C802, C804, C805, C806, C813, C814, C817: 4.7u/25V/0603; C_0603_1608Metric; MPN TCC0603X5R475M250CT; LCSC C20539423
C807, C809, C810: 1u/50V/0603; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
C808: 47n/50V/0603; C_0603_1608Metric; MPN CL10B473KB8NNNC; LCSC C1622
C815: 100n/25V/0402; C815_Display; MPN 0402B104K250NT; LCSC C56392
C818: 2.2u/10V/0402; C_0402_1005Metric; MPN TCC0402X5R225M100AT; LCSC C18164608
D801, D802: 1N5819WS; D_SOD-323; MPN 1N5819WS; LCSC C191023
J820: X05A10L40G / E0470A01; J820_Display; MPN X05A10L40G; LCSC C21261162
L801, L802: 4.7uH; L_Changjiang_FNR4012S; MPN WPN4012H4R7MT; LCSC C370623
R726: 22; R726_Core; MPN 0402WGF220JTCE; LCSC C25092
R801: 442k/1%; R801_Display; MPN 0402WGF4423TCE; LCSC C5101
R802: 21k/1%; R802_Display; MPN 0402WGF2102TCE; LCSC C25766
R803: 750k/1%; R803_Display; MPN 0402WGF7503TCE; LCSC C122545
R804: 59k/1%; R804_Display; MPN 0402WGF5902TCE; LCSC C32297
R805: 7.5k/1%; R805_Display; MPN RC-02K7501FT; LCSC C140131
R806: 36k/1%; R806_Display; MPN RC-02K3602FT; LCSC C324808
R807: 10k; R807_Display; MPN 0402WGF1002TCE; LCSC C25744
R808: 100k; R808_Display; MPN RC-02K1003FT; LCSC C140219
R809: 100k; R809_Display; MPN RC-02K1003FT; LCSC C140219
R810: 100k; R810_Display; MPN RC-02K1003FT; LCSC C140219
R811: 100k; R811_Display; MPN RC-02K1003FT; LCSC C140219
TH801: 10k NTC B3380 1%; TH801_Display; MPN SDNT1005X103F3380FTF; LCSC C279776
TP801: P47_VGH; TP801_Display; MPN NOT_A_PURCHASED_PART
TP803: P47_VPOS; TP803_Display; MPN NOT_A_PURCHASED_PART
TP804: P47_VNEG; TP804_Display; MPN NOT_A_PURCHASED_PART
TP805: P47_VCOM; TP805_Display; MPN NOT_A_PURCHASED_PART
TP806: P47_BORDER_REVIEW; TP806_Display; MPN NOT_A_PURCHASED_PART
U810: SY7636ARMC; U810_Display; MPN SY7636ARMC; LCSC C22451321

Connections:
3V3_AON: J820.5, J820.11, J820.34, R807.2; also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C809.2, C810.2, C813.2, C814.2, C815.2, C817.2, C818.2, J820.9, J820.12, J820.22, J820.MP, L802.2, R802.2, R806.2, R808.2, R809.2, R810.2, R811.2, TH801.2, U810.8 (AGND1), U810.32 (PGND2), U810.41 (PGND1), U810.48 (AGND2); also elsewhere on the board
I2C_SCL: U810.17 (SCL); also elsewhere on the board
I2C_SDA: U810.18 (SDA); also elsewhere on the board
P47_BORDER_REVIEW: J820.40, TP806.1
P47_CKV: J820.7; also elsewhere on the board
P47_D0: J820.14; also elsewhere on the board
P47_D1: J820.15; also elsewhere on the board
P47_D2: J820.16; also elsewhere on the board
P47_D3: J820.17; also elsewhere on the board
P47_D4: J820.18; also elsewhere on the board
P47_D5: J820.19; also elsewhere on the board
P47_D6: J820.20; also elsewhere on the board
P47_D7: J820.21; also elsewhere on the board
P47_D8: J820.23; also elsewhere on the board
P47_D9: J820.24; also elsewhere on the board
P47_D10: J820.25; also elsewhere on the board
P47_D11: J820.26; also elsewhere on the board
P47_D12: J820.27; also elsewhere on the board
P47_D13: J820.28; also elsewhere on the board
P47_D14: J820.29; also elsewhere on the board
P47_D15: J820.30; also elsewhere on the board
P47_HV_EN: R808.1, U810.21 (EN); also elsewhere on the board
P47_MODE: J820.6, R810.1; also elsewhere on the board
P47_PGOOD: R807.1, U810.23 (PGOOD); also elsewhere on the board
P47_PUMP_POS: C808.1; also elsewhere on the board
P47_SPV: J820.8; also elsewhere on the board
P47_TS: R805.2, R806.1, TH801.1, U810.47 (TS)
P47_VCC: C814.1, U810.7 (VCC)
P47_VCOM: C813.1, J820.10, TP805.1, U810.15 (VCOM)
P47_VCOM_EN: R809.1, U810.12 (VCOM_EN); also elsewhere on the board
P47_VEE_BASE: C810.1, U810.30 (VEE_D); also elsewhere on the board
P47_VEE_DRV: U810.28 (VEE_DRV); also elsewhere on the board
P47_VEE_FB: R803.2, R804.1, U810.31 (VEE_FB)
P47_VGH: C809.1, J820.3, R801.1, TP801.1, U810.35 (VDDH_DIS); also elsewhere on the board
P47_VGH_BASE: C807.1, U810.34 (VDDH_D); also elsewhere on the board
P47_VGH_DRV: C808.2, U810.36 (VDDH_DRV)
P47_VGH_FB: R801.2, R802.1, U810.33 (VDDH_FB)
P47_VGL: J820.1, R803.1; also elsewhere on the board
P47_VN: C804.1, C817.1, D802.2 (A), U810.4 (VNEG_IN), U810.26 (VN)
P47_VNEG: C806.1, J820.38, TP804.1, U810.3 (VNEG)
P47_VN_LX: D802.1 (K), L802.1, U810.25 (VN_LX)
P47_VP: C802.1, D801.1 (K), U810.42 (VP)
P47_VPOS: C805.1, J820.36, TP803.1, U810.44 (VPOS)
P47_VP_LX: D801.2 (A), L801.2, U810.40 (VP_LX)
P47_VREF: C815.1, R804.2, R805.1, U810.1 (VREF)
P47_XCL: J820.13, R726.2
P47_XCL_SRC: R726.1; also elsewhere on the board
P47_XLE: J820.32; also elsewhere on the board
P47_XOE: J820.33, R811.1; also elsewhere on the board
P47_XSTL: J820.31; also elsewhere on the board
VSYS_RAW: C801.1, C803.1, C818.1, L801.1, U810.10 (VIN), U810.24 (VN_IN); also elsewhere on the board

Notes on the sheet:
EPD power SY7636A, panel and touch connectors (1/2)

Schematic: Panda47-v024-epd2.kicad_sch, EPD power SY7636A, panel and touch connectors (2/2)

Parts:
C811: 47n/50V/0603; C_0603_1608Metric; MPN CL10B473KB8NNNC; LCSC C1622
C812: 1u/50V/0603; C_0603_1608Metric; MPN CL10A105KB8NNNC; LCSC C15849
D803: BAV99; D803_Display; MPN BAV99; LCSC C68983
D804: BAV99; D804_Display; MPN BAV99; LCSC C68983
J803: X05A10H06G; J803_Core; MPN X05A10H06G; LCSC C528032
J804: X05A10H06G; J804_Core; MPN X05A10H06G; LCSC C528032
R812: 100k; R812_Display; MPN RC-02K1003FT; LCSC C140219
R910: 10k / TOUCH_INT_PU; R910_Core; MPN 0402WGF1002TCE; LCSC C25744
R911: 10k / TOUCH_RST_PU; R911_Core; MPN 0402WGF1002TCE; LCSC C25744
TP802: P47_VGL; TP802_Display; MPN NOT_A_PURCHASED_PART

Connections:
3V3_AON: J803.2 (VDD3V3), R910.1, R911.1; also elsewhere on the board
FL_C_N: J804.5 (SDA); also elsewhere on the board
FL_VOUT: J804.2 (VDD3V3), J804.6 (SCL); also elsewhere on the board
FL_W_N: J804.1 (GND); also elsewhere on the board
GND: C812.2, J803.1 (GND), R812.2; also elsewhere on the board
I2C_SCL: J803.6 (SCL); also elsewhere on the board
I2C_SDA: J803.5 (SDA); also elsewhere on the board
P47_PUMP_NEG: C811.1, D804.3 (K1_A2)
P47_PUMP_POS: D803.3 (K1_A2); also elsewhere on the board
P47_VEE_BASE: D804.2 (K2); also elsewhere on the board
P47_VEE_DRV: C811.2; also elsewhere on the board
P47_VGH: D803.2 (K2); also elsewhere on the board
P47_VGH_BASE: D803.1 (A1); also elsewhere on the board
P47_VGL: C812.1, D804.1 (A1), R812.1, TP802.1; also elsewhere on the board
TOUCH_INT: J803.4 (INT), R910.2; also elsewhere on the board
TOUCH_RST: J803.3 (RST), R911.2; also elsewhere on the board

Notes on the sheet:
EPD power SY7636A, panel and touch connectors (2/2)

Schematic: Panda47-v024-power.kicad_sch, Charger, fuel gauge, cell protection, audio and front light

Parts:
C201: 47n / CBOOT; C201_Core; MPN CL10B473KB8NNNC; LCSC C1622
C203: 10u / PMID; C203_Core; MPN CL31A106KBHNNNE; LCSC C13585
C205: 4.7u / REGN; C205_Core; MPN CL21A475KAQNNNE; LCSC C1779
C206: 10u / BAT; C206_Core; MPN CL21A106KAYNNNE; LCSC C15850
C207: 22u / CSYS1; C207_Core; MPN CL21A226MAQNNNE; LCSC C45783
C208: 22u / CSYS2; C208_Core; MPN CL21A226MAQNNNE; LCSC C45783
C303: 1u / BQ BAT; C303_Core; MPN CL05A105KA5NQNC; LCSC C52923
C304: 2.2u / BQ VDD; C304_Core; MPN TCC0402X5R225M100AT; LCSC C18164608
C401: 22u / VIN; C401_Core; MPN TCC0603X5R226M100CT; LCSC C20416425
C404: 22pF; C_0402_1005Metric; MPN CL05C220JB5NNNC; LCSC C1555
C505: 100n / AUDIO_VDD; C505_Core; MPN CL05B104KB54PNC; LCSC C307331
C506: 10u / AUDIO_VDD; C506_Core; MPN CL10A106MA8NRNC; LCSC C96446
C903: 1u / CW2217 VCELL; C903_Core; MPN CL10A105KB8NNNC; LCSC C15849
C920: 4.7uF 16V X7R / FL_CIN; C920_Core; MPN CL21A475KAQNNNE; LCSC C1779
C923: 4.7uF 50V X7R / FL_COUT; C923_Core; MPN 1206B475K500NT; LCSC C29823
D203: Green side-view LED; LED_SideView_TJ-S1706; MPN TJ-S1706SW6TGLC2G-A5; LCSC C273616
D905: B5819W SL / FL_RECT; D905_Core; MPN B5819W SL; LCSC C8598
L401: 1uH; L_Murata_DFE201610P; MPN WPN201610H1R0MT; LCSC C97002
L402: 1uH; L_Changjiang_FNR4012S; MPN WPN4012H1R0MT; LCSC C316330
L905: 10uH / FL_BOOST; L905_Core; MPN SWPA252012S100MT; LCSC C37428
Q901, Q902: NX3008NBK,215-JSM; Q907_Core; MPN NX3008NBK,215-JSM; LCSC C53113911
R201: 5.6k / PSEL low leg; R201_Core; MPN 0603WAF5601T5E; LCSC C23189
R204: 1.2k / REGN to PSEL; R204_Core; MPN 0603WAF1201T5E; LCSC C22765
R401: 100k; R_0402_1005Metric; MPN 0402WGF1003TCE; LCSC C25741
R402: 22.1k; R_0402_1005Metric; MPN 0402WGF2212TCE; LCSC C43473
R615: 5.23k; R615_Core; MPN RS-03K5231FT; LCSC C140082
R616: 30.1k; R616_Core; MPN RS-03K3012FT; LCSC C321843
R903: 100R / CW2217 VDD; R903_Core; MPN 0603WAF1000T5E; LCSC C22775
R904: 100R / CW2217 VCELL; R904_Core; MPN 0603WAF1000T5E; LCSC C22775
R921: 10R 1%; R_0402_1005Metric; MPN 0402WGF100JTCE; LCSC C25077
SW202: TS-1186E-B-B; SW202_Core; MPN TS-1186E-B-B; LCSC C2885153
TP1: VBUS_USB; TP1_Core; MPN NOT_A_PURCHASED_PART
TP2: VSYS_RAW; TP2_Core; MPN NOT_A_PURCHASED_PART
TP5: FL_VOUT; TP11_Core; MPN NOT_A_PURCHASED_PART
TP11: I2C_SCL; TP11_Core; MPN NOT_A_PURCHASED_PART
TP12: I2C_SDA; TP12_Core; MPN NOT_A_PURCHASED_PART
TPG2: GND; TP11_Core; MPN NOT_A_PURCHASED_PART
U901: SGM41513YTQF24G/TR; U901_Core; MPN SGM41513YTQF24G/TR; LCSC C5153778
U902: SY8089A1AAC; SOT-23-5; MPN SY8089A1AAC; LCSC C479074
U903: CW2217BAAD; U903_Core; MPN CW2217BAAD; LCSC C5203993
U904: NS4168; U904_Core; MPN NS4168; LCSC C910588
U905: SGM3732YTN6G/TR; TSOT-23-6; MPN SGM3732YTN6G/TR; LCSC C116578

Connections:
3V3_AON: C404.1, L401.2, R401.1; also elsewhere on the board
AUDIO_EN: U904.1 (CTRL); also elsewhere on the board
BAT_CONN_P: R904.1, U903.8 (CSN); also elsewhere on the board
BAT_PACKP: C206.1, C303.1, R903.1, U901.13 (BAT), U901.14 (BAT), U903.7 (CSP); also elsewhere on the board
BQ_INT: U901.7 (nINT); also elsewhere on the board
BQ_QON: SW202.1, U901.12 (nQON)
BQ_TS: R615.2, R616.1, U901.11 (TS), U903.9 (TS); also elsewhere on the board
BUCK_FB: C404.2, R401.2, R402.1, U902.5 (FB)
BUCK_LX: L401.1, U902.3 (LX)
CHG_LED_A: D203.2; also elsewhere on the board
CHG_STAT: D203.1, U901.4 (STAT)
FL_C_EN: Q902.1 (G); also elsewhere on the board
FL_C_N: Q902.2 (D); also elsewhere on the board
FL_FB: Q901.3 (S), Q902.3 (S), R921.1, U905.3 (FB)
FL_PWM: U905.4 (CTRL); also elsewhere on the board
FL_SW: D905.2 (A), L905.2, U905.1 (SW)
FL_VOUT: C923.1, D905.1 (K), TP5.1, U905.5 (VOUT); also elsewhere on the board
FL_W_EN: Q901.1 (G); also elsewhere on the board
FL_W_N: Q901.2 (D); also elsewhere on the board
FUEL_GPOUT: U903.1 (INT_N); also elsewhere on the board
FUEL_VCELL: C903.1, R904.2, U903.4 (VCELL)
FUEL_VDD: C304.1, R903.2, U903.3 (VDD)
GND: C203.2, C205.2, C206.2, C207.2, C208.2, C303.2, C304.2, C401.2, C505.2, C506.2, C903.2, C920.2, C923.2, R201.2, R402.2, R616.2, R921.2, SW202.2, TPG2.1, U901.9 (nCE), U901.17 (GND), U901.18 (GND), U901.25 (GND), U902.2 (GND), U903.6 (VSS), U903.13 (PAD), U904.7 (GND), U904.9 (EP), U905.2 (GND); also elsewhere on the board
I2C_SCL: TP11.1, U901.5 (SCL), U903.11 (SCL); also elsewhere on the board
I2C_SDA: TP12.1, U901.6 (SDA), U903.10 (SDA); also elsewhere on the board
I2S_BCLK: U904.3 (BCLK); also elsewhere on the board
I2S_DIN: U904.4 (SDATA); also elsewhere on the board
I2S_LRCLK: U904.2 (LRCLK); also elsewhere on the board
SGM41513_BTST: C201.1, U901.21 (BTST)
SGM41513_PMID: C203.1, U901.23 (PMID)
SGM41513_PSEL: R201.1, R204.1, U901.2 (PSEL)
SGM41513_REGN: C205.1, R204.2, R615.1, U901.22 (REGN)
SGM41513_SW: C201.2, L402.1, U901.19 (SW), U901.20 (SW)
SPK_N: U904.5 (VON); also elsewhere on the board
SPK_P: U904.8 (VOP); also elsewhere on the board
VBUS_USB: TP1.1, U901.1 (VAC), U901.24 (VBUS); also elsewhere on the board
VSYS_RAW: C207.1, C208.1, C401.1, C505.1, C506.1, C920.1, L402.2, L905.1, TP2.1, U901.15 (SYS), U901.16 (SYS), U902.1 (EN), U902.4 (IN), U904.6 (VDD), U905.6 (VIN); also elsewhere on the board

Notes on the sheet:
Charger, fuel gauge, cell protection, audio and front light

Board: 4 copper layers, 63.0 x 48.0 mm, 182 parts (7 on the bottom side), 121 nets.

Other parts of the board:
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
MH1: Locating hole; LocHole_NPTH_1.2
MH2: Locating hole; LocSlot_NPTH_1.2x1.6

## KiCad design hardware/pico47/v0.1.2/Single.kicad_pcb

File hardware/pico47/v0.1.2/README.md:

# Panda Standard — Single 4-Layer PCB (`v0.1.2` / `R49`)

- **Board**: `Single.kicad_pcb`, 71.0 × 99.0 mm L-step four-layer board, R49 (= R48 layout + front-light supply fix).
- **Schematic**: `Single.kicad_sch` (index page) + 11 A4/A3 sheets `Single-*.kicad_sch`, drawn in the usual style (see below). Same 265 parts, pins and 255 nets as the R49 netlist-style source.
- **Native checks** (KiCad 10.0.7, this directory alone): DRC 0 errors / 0 warnings / 0 unconnected / 0 schematic parity, ERC 0.
- **Rebuild**: `python3 build_pico47_single_r49.py --output <new dir under .work>` (KiCad Python) replays R26 → R48 → R49, writes this schematic and the JLC order pack; `--netlist-style-schematic` keeps the one-label-per-pin form.
- **Status**: `manufacturing_release = false`. Ordering prerequisites are listed in [R49 note](../E02-R49-FRONTLIGHT-SUPPLY-20261106.md) (46 Type VII via-in-pad CAM confirmation, current 13 pending SMT parts, BT301 post-SMT). The 2026-11-08 exact-MPN catalog metadata ECO is recorded in [R49 SMT catalog cleanup](../E02-R49-SMT-CATALOG-CLEANUP-20261108.md); the original R49 pending list was 21 parts and no electrical substitution was made.

## Changes vs. `v0.1.1`

1. R27–R48 layout revisions (see `../E02-R27-LAYOUT-FIXES-20261031.md` … `../E02-R48-XSTL-AND-CKV-BRIDGES-20261103.md`).
2. R49: the front-light boost input `VSYS_FL_IN` (L905 / R920 / C920) had no supply after the board merge; it now joins `VSYS_RAW` via a 0.40 mm, 29 mm link.
3. The schematic is redrawn by `../readable_schematic.py` as a hierarchical design:

| Sheet | Content |
|---|---|
| `USB_Input` | J201 USB-C, CC resistors, D201 / D202 ESD |
| `Battery_RTC` | J301 / J302 battery landings, R306 sense, U302 SD3078 RTC, BT301 |
| `Load_Switches` | U402–U405 SGM2578 rails |
| `MCU_1`, `MCU_2` | U501 ESP32-S3 with straps and bypass, U503 IMU, series resistors; U506 Flash, J501 microSD, J503 debug, Y501 |
| `IO_Expander` | U601 XL9535 and its pull resistors |
| `Panel_SD_Mux` | U710 / U711 SGM330A and their series resistors |
| `EPD_PMIC_1`, `EPD_PMIC_2` | U810 SY7636A, U811 expander, rectifiers; J820 panel, J803 touch, J804 front light, D803 / D804 charge pumps |
| `Charger_Power_1`, `_2` | U901 charger, U902 buck-boost, U903 gauge, U904 audio, U905 front light; U906 reset, U907 protection, Q907 / Q908 |

ICs and connectors are boxes with supply pins on top, ground pins at the bottom and signal pins on both sides; resistors, capacitors, inductors, diodes, the crystal, MOSFETs, buttons, the coin cell and test points use the KiCad standard-library drawings. A part with one end on ground or a supply hangs off the pin it serves (the owner is the nearest same-net pin on the PCB); decoupling groups share a supply bar; series parts sit in a column with a label at each end. Connections between parts are global labels, supplies are power symbols, unused pins carry a no-connect flag. Two power flags (`3V3_TOUCH`, `3V3_EPD_LOGIC`) are schematic-only ERC drivers.

The visible `Spec` field shows the part of `Value` before “/” (for example `100nF 25V X7R`); the full `Value` is unchanged and hidden. `Spec` is also on every footprint as a hidden Fab-layer field so the schematic-parity check stays at zero; copper, pads, positions and the Gerbers are unchanged. The build aborts if the regenerated netlist differs in any pin set or net name.

## Importing into EasyEDA Pro (嘉立创EDA专业版)

Import the project zip (all files at its root) with *File → Import → KiCad*. EasyEDA Pro documents KiCad import for versions below 10.0. The schematic files are written in the KiCad 9 format (`20250114`); the board is KiCad 10 (`20260206`), so the board import may be refused; copper zones are always rebuilt on import and must be re-checked. Fabrication itself only needs the Gerber / BOM / CPL from the order pack.

Notes on the sheet:
Panda Standard 4.7 Single 主板原理图（v0.1.2 / R49）
各页之间以同名全局标签与电源符号相连；网表与 R49 PCB 完全一致。
USB-C 接口与 ESD 防护
电池接口与 RTC（SD3078）
分路负载开关 SGM2578
ESP32-S3、IMU、Flash、microSD 与调试（1/2）
ESP32-S3、IMU、Flash、microSD 与调试（2/2）
IO 扩展 XL9535
屏幕数据 / microSD 多路开关
墨水屏电源 SY7636A 与面板、触摸、前光接口（1/2）
墨水屏电源 SY7636A 与面板、触摸、前光接口（2/2）
充电、3V3 升降压、电量计、音频与前光驱动（1/2）
充电、3V3 升降压、电量计、音频与前光驱动（2/2）

Parts:
C202: 1u / VBUS; C202_Core; MPN 0603B105K250NT; LCSC C59302
C209: 1u; C209_Core; MPN 0603B105K250NT; LCSC C59302
D201: LRC8804FDT1G; D201_Core; MPN LRC8804FDT1G; LCSC C2856698
D202: SGM05HU1ALXUGY2G/TR; D202_Core; MPN SGM05HU1ALXUGY2G/TR; LCSC C55274065
J201: U22401-17 / MID-MOUNT; J201_Core; MPN U22401-17
R206: 5.1k ±5% / USB-C Rd; R206_Core; Tolerance 5%; MPN RC-02K512JT; LCSC C453708
R207: 5.1k ±5% / USB-C Rd; R207_Core; Tolerance 5%; MPN RC-02K512JT; LCSC C453708

Connections:
GND: C202.2, C209.2, D201.3 (GND), D201.8 (GND), D202.2 (A), J201.A1, J201.A12, J201.B1, J201.B12, J201.SH, R206.1, R207.1; also elsewhere on the board
USB_CC1: D201.4 (IO4), J201.A5, R206.2
USB_CC2: D201.5 (IO5), J201.B5, R207.2
USB_DM: D201.2 (IO2), J201.A7, J201.B7; also elsewhere on the board
USB_DP: D201.1 (IO1), J201.A6, J201.B6; also elsewhere on the board
VBUS_USB: C202.1, C209.1, D202.1 (K), J201.A4, J201.A9, J201.B4, J201.B9; also elsewhere on the board

Notes on the sheet:
USB-C 接口与 ESD 防护

Parts:
BT301: CR1216 / RTC PRIMARY; BT301_Core; MPN CR1216
C302: 100n / RTC VDD; C302_Core; MPN 0402B104K250NT; LCSC C56392
D306: BAT54WS / RTC charge block; D306_Core; MPN BAT54WS; LCSC C438012
J301: SOLDER LANDING / J301; J301_Core; MPN NOT_A_PURCHASED_PART
J302: SOLDER LANDING / J302; J302_Core; MPN NOT_A_PURCHASED_PART
R301: 1M / SCL PD DNP; R301_Core; MPN RC-02K1004FT; not fitted
R302: 1M / SDA PD DNP; R302_Core; MPN RC-02K1004FT; not fitted
R305: 100k / IRQ PU DNP; R305_Core; MPN RC-02K1003FT; LCSC C140219; not fitted
R306: 10m / CW2217 SHUNT; R306_Core; Tolerance 1%; MPN FRM121WFR010TM; LCSC C7467248
TH301: MF52D-103F3435-100 10k B3435 external NTC; MPN MF52D-103F3435-100; LCSC C394023
TP3: 3V3_AON; TP3_Core; MPN NOT_A_PURCHASED_PART
U302: SD3078; U302_Core; MPN SD3078; LCSC C916255

Connections:
3V3_AON: C302.1, R305.1, TP3.1 (1_1), U302.3 (VDD); also elsewhere on the board
BAT_CELL_N: J301.2; also elsewhere on the board
BAT_CONN_P: J301.1, R306.1; also elsewhere on the board
BAT_PACKP: R306.2; also elsewhere on the board
BQ_TS: J302.1, TH301.1; also elsewhere on the board
EXP_INT: R305.2, U302.7 (INT); also elsewhere on the board
GND: BT301.2, C302.2, J302.2, R301.2, R302.2, TH301.2, U302.6 (GND); also elsewhere on the board
I2C_SCL: R301.1, U302.1 (SCL); also elsewhere on the board
I2C_SDA: R302.1, U302.8 (SDA); also elsewhere on the board
RTC_CELL_P: BT301.1, D306.2 (A)
RTC_VBACKUP: D306.1 (K), U302.5 (VBAT)

Notes on the sheet:
电池接口与 RTC（SD3078）

Parts:
C401: 22u / VIN; C401_Core; MPN 0603X226M100NT; LCSC C60077
C507: 1u / U405 VIN; C507_Core; MPN 0603B105K250NT; LCSC C59302
C516: 1u / U403 VOUT; C516_Core; MPN 0603B105K250NT; LCSC C59302
C532: 1uF 10V X5R / U404 COUT; C532_Core; MPN 0402X105K100NT; LCSC C157353
C533: 1uF 10V X5R / U402 COUT; C533_Core; MPN 0402X105K100NT; LCSC C157353
C534: 1uF 10V X5R / U403 COUT; C534_Core; MPN 0402X105K100NT; LCSC C157353
C535: 1uF 10V X5R / U405 COUT; C535_Core; MPN 0402X105K100NT; LCSC C157353
R507: 100k / AUDIO_EN_PD; R507_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R508: 0R / MB6 AUDIO; R508_Core; MPN RS-05000FT; LCSC C132364
R514: 0R / MB3 SD; R514_Core; MPN RS-05000FT; LCSC C132364
R515: 0R / MB4 TOUCH; R515_Core; MPN RS-05000FT; LCSC C132364
R516: 0R / MB5 EPD; R516_Core; MPN RS-05000FT; LCSC C132364
TPG6: GND; TPG6_Core; MPN NOT_A_PURCHASED_PART
U402: SGM2578SDYG/TR; U402_Core; MPN SGM2578SDYG/TR
U403: SGM2578SDYG/TR; U403_Core; MPN SGM2578SDYG/TR
U404: SGM2578SDYG/TR; U404_Core; MPN SGM2578SDYG/TR
U405: SGM2578SDYG/TR; U405_Core; MPN SGM2578SDYG/TR

Connections:
3V3_AON: U402.A2 (VIN_A2), U403.A2 (VIN_A2), U404.A2 (VIN_A2); also elsewhere on the board
3V3_EPD_LOGIC: R516.2; also elsewhere on the board
3V3_EPD_LOGIC_SW: C532.1, R516.1, U404.A1 (VOUT_A1)
3V3_SD: R514.2; also elsewhere on the board
3V3_SD_SW: C533.1, R514.1, U402.A1 (VOUT_A1)
3V3_TOUCH: R515.2; also elsewhere on the board
3V3_TOUCH_SW: C516.1, C534.1, R515.1, U403.A1 (VOUT_A1)
EN_3V3_EPD_LOGIC: U404.B2 (ON_B2); also elsewhere on the board
EN_3V3_SD: U402.B2 (ON_B2); also elsewhere on the board
EN_3V3_TOUCH: U403.B2 (ON_B2); also elsewhere on the board
EN_VSYS_AUDIO: R507.1, U405.B2 (ON_B2); also elsewhere on the board
GND: C401.2, C507.2, C516.2, C532.2, C533.2, C534.2, C535.2, R507.2, TPG6.1 (1_1), U402.B1 (GND_B1), U403.B1 (GND_B1), U404.B1 (GND_B1), U405.B1 (GND_B1); also elsewhere on the board
VSYS_AUDIO: R508.2; also elsewhere on the board
VSYS_AUDIO_SW: C535.1, R508.1, U405.A1 (VOUT_A1)
VSYS_RAW: C401.1, C507.1, U405.A2 (VIN_A2); also elsewhere on the board

Notes on the sheet:
分路负载开关 SGM2578
