# Repository Panda-Intelligence/panda-standard-board (continued)

## KiCad design hardware/pico47/v0.1.2/Single.kicad_pcb (continued)

Parts:
C501: 22u / ESP32; C501_Core; MPN 0603X226M100NT; LCSC C60077
C502: 100n / ESP32; C502_Core; MPN 0402B104K250NT; LCSC C56392
C508: 1u / U402 VIN; C508_Core; MPN 0603B105K250NT; LCSC C59302
C509: 1u / U403 VIN; C509_Core; MPN 0603B105K250NT; LCSC C59302
C510: 1u / CHIP_PU; C510_Core; MPN 0603B105K250NT; LCSC C59302
C514: DNP / USB tuning; C514_Core; MPN 0402CG0R8C500NT; LCSC C40459; not fitted
C515: DNP / USB tuning; C515_Core; MPN 0402CG0R8C500NT; LCSC C40459; not fitted
C522: 100n; C522_Core; MPN 0402B104K250NT; LCSC C56392
C523: 100n; C523_Core; MPN 0402B104K250NT; LCSC C56392
C524: 100n; C524_Core; MPN 0402B104K250NT; LCSC C56392
C525: 22u / local RF supply; C525_Core; MPN 0805X226M250NT; LCSC C129303
C526: 100n; C526_Core; MPN 0402B104K250NT; LCSC C56392
C527: 1u; C527_Core; MPN 0402B105K100NT; LCSC C1526
C530: 0.8p / RF; C530_Core; MPN 0402CG0R8C500NT; LCSC C40459
C537: 100nF 25V X7R / U501 VDD_SPI; C537_Core; MPN 0402B104K250NT; LCSC C56392
C538: 1uF 10V X5R / U501 VDD_SPI; C538_Core; MPN 0402X105K100NT; LCSC C157353
C539: 100nF 25V X7R / U503 VDD_IO; C539_Core; MPN 0402B104K250NT; LCSC C56392
C540: 100nF 25V X7R / U503 VDD; C540_Core; MPN 0402B104K250NT; LCSC C56392
C541: 100nF 25V X7R / U601 VCC; C541_Core; MPN 0402B104K250NT; LCSC C56392
L506: 24nH / crystal; L506_Core; MPN SDCL1005C24NJTDF; LCSC C74301
L507: 2nH / RF supply; L507_Core; MPN SDCL1608C2N0STDF; LCSC C370234
L508: 2nH / RF match; L508_Core; MPN SDCL1005C2N0STDF; LCSC C43365
R501: 100k / IMU_INT1; R501_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R502: 100k / EXP_INT_PU; R502_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R510: 10k / CHIP_PU; R510_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R511: 10k / GPIO0; R511_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R512: 10k / GPIO3; R512_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R513: 10k / GPIO46; R513_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R528: 10k; R528_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R529: 22; R529_Core; MPN RC-02K22R0FT; LCSC C324769
R530: 22; R530_Core; MPN RC-02K22R0FT; LCSC C324769
R533: 1k / CHIP_PU_DEBUG_SERIES; R533_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1001FT; LCSC C140197
R718: 22; R718_Core; MPN RC-02K22R0FT; LCSC C324769
R719: 22; R719_Core; MPN RC-02K22R0FT; LCSC C324769
R720: 22; R720_Core; MPN RC-02K22R0FT; LCSC C324769
R721: 22; R721_Core; MPN RC-02K22R0FT; LCSC C324769
R722: 22; R722_Core; MPN RC-02K22R0FT; LCSC C324769
R723: 22; R723_Core; MPN RC-02K22R0FT; LCSC C324769
R724: 22; R724_Core; MPN RC-02K22R0FT; LCSC C324769
R725: 22; R725_Core; MPN RC-02K22R0FT; LCSC C324769
R726: 22; R726_Core; MPN RC-02K22R0FT; LCSC C324769
R727: 22; R727_Core; MPN RC-02K22R0FT; LCSC C324769
R728: 22; R728_Core; MPN RC-02K22R0FT; LCSC C324769
R729: 22; R729_Core; MPN RC-02K22R0FT; LCSC C324769
R730: 22; R730_Core; MPN RC-02K22R0FT; LCSC C324769
R731: 10k; R731_Core; MPN RC-02K1002FT; LCSC C140215
SW201: TS-1186E-B-B; SW201_Core; MPN TS-1186E-B-B; LCSC C2885153
TP18: CHIP_PU; TP18_Core; MPN NOT_A_PURCHASED_PART
TPG1: GND; TPG1_Core; MPN NOT_A_PURCHASED_PART
U501: ESP32-S3R8; U501_Core; MPN ESP32-S3R8; LCSC C2913194
U503: QMI8658A; U503_Core; MPN QMI8658A; LCSC C3021082

Connections:
3V3_AON: C501.1, C502.1, C508.1, C509.1, C522.1, C523.1, C526.1, C527.1, C539.1, C540.1, C541.1, L507.1, R502.2, R510.1, R511.1, R528.1, U501.20 (VDD3P3_RTC_20), U501.46 (VDD3P3_CPU_46), U501.55 (VDDA_55), U501.56 (VDDA_56), U503.1 (SDO/SA0), U503.5 (Vdd_IO), U503.8 (Vdd), U503.12 (CS); also elsewhere on the board
3V3_RF: C524.1, C525.1, L507.2, U501.2 (VDD3P3_2), U501.3 (VDD3P3_3)
CHIP_PU_DEBUG: R533.2; also elsewhere on the board
CHIP_PU_MCU: C510.1, R510.2, R533.1, TP18.1 (1_1), U501.4 (CHIP_PU_4)
EXP_INT: R502.1, U501.9 (GPIO4); also elsewhere on the board
GND: C501.2, C502.2, C508.2, C509.2, C510.2, C514.2, C515.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C530.2, C537.2, C538.2, C539.2, C540.2, C541.2, R501.2, R512.2, R513.2, R731.2, SW201.2, TPG1.1 (1_1), U501.57 (GND_57), U503.2 (SDx), U503.3 (SCx), U503.6 (GND), U503.7 (GND); also elsewhere on the board
GPIO0: R511.2, U501.5 (GPIO0); also elsewhere on the board
HW_ARM_GPIO: U501.7 (GPIO2); also elsewhere on the board
I2C_SCL: U501.22 (GPIO16), U503.13 (SCL); also elsewhere on the board
I2C_SDA: U501.21 (GPIO15), U503.14 (SDA); also elsewhere on the board
I2S_BCLK: U501.27 (GPIO21); also elsewhere on the board
I2S_DIN: U501.23 (GPIO17); also elsewhere on the board
I2S_LRCLK: U501.24 (GPIO18); also elsewhere on the board
IMU_INT1: R501.1, U503.4 (INT1); also elsewhere on the board
KEY_POWER_MCU: R528.2, SW201.1, U501.6 (GPIO1)
LNA_IN: C530.1, L508.1, U501.1 (LNA_IN_1)
P47_BUS_SELECT: R513.1, U501.52 (GPIO46); also elsewhere on the board
P47_CKV: R729.2; also elsewhere on the board
P47_CKV_SRC: R729.1, U501.17 (GPIO12)
P47_D8: R718.2; also elsewhere on the board
P47_D8_SRC: R512.1, R718.1, U501.8 (GPIO3)
P47_D9: R719.2; also elsewhere on the board
P47_D9_SRC: R719.1, U501.47 (GPIO41)
P47_D10: R720.2; also elsewhere on the board
P47_D10_SRC: R720.1, U501.43 (GPIO38)
P47_D11: R721.2; also elsewhere on the board
P47_D11_SRC: R721.1, U501.44 (GPIO39)
P47_D12: R722.2; also elsewhere on the board
P47_D12_SRC: R722.1, U501.37 (GPIO47)
P47_D13: R723.2; also elsewhere on the board
P47_D13_SRC: R723.1, U501.16 (GPIO11)
P47_D14: R724.2; also elsewhere on the board
P47_D14_SRC: R724.1, U501.48 (GPIO42)
P47_D15: R725.2; also elsewhere on the board
P47_D15_SRC: R725.1, U501.45 (GPIO40)
P47_MUX0: U501.13 (GPIO8); also elsewhere on the board
P47_MUX1: U501.14 (GPIO9); also elsewhere on the board
P47_MUX2: U501.15 (GPIO10); also elsewhere on the board
P47_MUX3: U501.50 (GPIO44); also elsewhere on the board
P47_MUX4: U501.12 (GPIO7); also elsewhere on the board
P47_MUX5: U501.49 (GPIO43); also elsewhere on the board
P47_MUX6: U501.10 (GPIO5); also elsewhere on the board
P47_MUX7: U501.11 (GPIO6); also elsewhere on the board
P47_SPV: R730.2; also elsewhere on the board
P47_SPV_SRC: R730.1, U501.36 (GPIO48)
P47_XCL: R726.2; also elsewhere on the board
P47_XCL_SRC: R726.1, U501.19 (GPIO14)
P47_XLE: R727.2; also elsewhere on the board
P47_XLE_SRC: R727.1, U501.18 (GPIO13)
P47_XSTL: R728.2; also elsewhere on the board
P47_XSTL_SRC: R728.1, R731.1, U501.51 (GPIO45)
RF_ANT: L508.2; also elsewhere on the board
SPICLK_SOC: U501.33 (SPICLK_33); also elsewhere on the board
SPICS0_SOC: U501.32 (SPICS0_32); also elsewhere on the board
SPID_SOC: U501.35 (SPID_35); also elsewhere on the board
SPIHD_SOC: U501.30 (SPIHD_30); also elsewhere on the board
SPIQ_SOC: U501.34 (SPIQ_34); also elsewhere on the board
SPIWP_SOC: U501.31 (SPIWP_31); also elsewhere on the board
USB_DM: R530.1; also elsewhere on the board
USB_DM_MCU: C515.1, R530.2, U501.25 (GPIO19)
USB_DP: R529.1; also elsewhere on the board
USB_DP_MCU: C514.1, R529.2, U501.26 (GPIO20)
VDD_SPI: C537.1, C538.1, U501.29 (VDD_SPI_29); also elsewhere on the board
XTAL_N: U501.53 (XTAL_N_53); also elsewhere on the board
XTAL_P: L506.2; also elsewhere on the board
XTAL_P_SOC: L506.1, U501.54 (XTAL_P_54)

Notes on the sheet:
ESP32-S3、IMU、Flash、microSD 与调试（1/2）

Parts:
C503: 100n / VDD_IO; C503_Core; MPN 0402B104K250NT; LCSC C56392
C504: 100n / VDD; C504_Core; MPN 0402B104K250NT; LCSC C56392
C511: 1u / U404 VIN; C511_Core; MPN 0603B105K250NT; LCSC C59302
C512: 100n / SD VDD; C512_Core; MPN 0402B104K250NT; LCSC C56392
C513: 10u / SD VDD; C513_Core; MPN CGA0603X7R106K100JT; LCSC C22399626
C520: 100n; C520_Core; MPN 0402B104K250NT; LCSC C56392
C521: 1u; C521_Core; MPN 0402B105K100NT; LCSC C1526
C528: 18p / crystal; C528_Core; MPN 0402CG180J500NT; LCSC C1549
C529: 18p / crystal; C529_Core; MPN 0402CG180J500NT; LCSC C1549
C531: 0.8p / RF; C531_Core; MPN 0402CG0R8C500NT; LCSC C40459
C536: 1uF 10V X5R / U403 CIN; C536_Core; MPN 0402X105K100NT; LCSC C157353
C542: 100nF 25V X7R / U811 VCC; C542_Core; MPN 0402B104K250NT; LCSC C56392
C543: 100nF 25V X7R / U506 VCC; C543_Core; MPN 0402B104K250NT; LCSC C56392
J501: TF-122-CCP9 / microSD; J501_Core; MPN TF-122-CCP9; LCSC C41347844
J502: SOLDER LANDING / J502; J502_Core; MPN NOT_A_PURCHASED_PART
J503: TC2030-IDC-NL / DEBUG; J503_Core; MPN NOT_A_PURCHASED_PART
J507: RF COAX LANDING; J507_Core; MPN NOT_A_PURCHASED_PART
R517: 0R / SD series; R517_Core; MPN RS-03000FT; LCSC C136582
R518: 0R / SD series; R518_Core; MPN RS-03000FT; LCSC C136582
R519: 0R / SD series; R519_Core; MPN RS-03000FT; LCSC C136582
R520: 0R / SD series; R520_Core; MPN RS-03000FT; LCSC C136582
R521: 0R / SD series; R521_Core; MPN RS-03000FT; LCSC C136582
R522: 0R / SD series; R522_Core; MPN RS-03000FT; LCSC C136582
R523: 10k / SD pull-up; R523_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R524: 10k / SD pull-up; R524_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R525: 10k / SD pull-up; R525_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R526: 10k / SD pull-up; R526_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R527: 10k / SD pull-up; R527_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R540: 0R / Flash SI; R540_Core; MPN RC-02000FT; LCSC C140225
R541: 0R / Flash SI; R541_Core; MPN RC-02000FT; LCSC C140225
R542: 0R / Flash SI; R542_Core; MPN RC-02000FT; LCSC C140225
R543: 0R / Flash SI; R543_Core; MPN RC-02000FT; LCSC C140225
R544: 0R / Flash SI; R544_Core; MPN RC-02000FT; LCSC C140225
R545: 0R / Flash SI; R545_Core; MPN RC-02000FT; LCSC C140225
TP5: 3V3_SD; TP5_Core; MPN NOT_A_PURCHASED_PART
U506: GD25Q128ESIG; U506_Core; MPN GD25Q128ESIG; LCSC C2758105
Y501: 40MHz / 12pF; Y501_Core; MPN XL2EL89COI-111YLC-40M; LCSC C18214314

Connections:
3V3_AON: C503.1, C504.1, C511.1, C536.1, C542.1, J503.2; also elsewhere on the board
3V3_SD: C512.1, C513.1, J501.4 (VDD), R523.2, R524.2, R525.2, R526.2, R527.2, TP5.1 (1_1); also elsewhere on the board
CHIP_PU_DEBUG: J503.1; also elsewhere on the board
FLASH_CLK: R544.2, U506.6 (CLK)
FLASH_CS: R540.2, U506.1 (CS#)
FLASH_D: R543.2, U506.5 (IO0)
FLASH_HD: R545.2, U506.7 (IO3)
FLASH_Q: R541.2, U506.2 (IO1)
FLASH_WP: R542.2, U506.3 (IO2)
GND: C503.2, C504.2, C511.2, C512.2, C513.2, C520.2, C521.2, C528.2, C529.2, C531.2, C536.2, C542.2, C543.2, J501.6 (VSS), J501.10 (DET_A), J501.SH (SHIELD_SH), J503.4, J507.2, U506.4 (GND), Y501.2, Y501.4; also elsewhere on the board
GPIO0: J503.6; also elsewhere on the board
RF_ANT: C531.1, J507.1; also elsewhere on the board
SDMMC_CLK: R517.1; also elsewhere on the board
SDMMC_CLK_CARD: J501.5 (CLK), R517.2
SDMMC_CMD: R518.1; also elsewhere on the board
SDMMC_CMD_CARD: J501.3 (CMD), R518.2, R523.1
SDMMC_D0: R519.1; also elsewhere on the board
SDMMC_D0_CARD: J501.7 (DAT0), R519.2, R524.1
SDMMC_D1: R520.1; also elsewhere on the board
SDMMC_D1_CARD: J501.8 (DAT1), R520.2, R525.1
SDMMC_D2: R521.1; also elsewhere on the board
SDMMC_D2_CARD: J501.1 (DAT2), R521.2, R526.1
SDMMC_D3: R522.1; also elsewhere on the board
SDMMC_D3_CARD: J501.2 (DAT3/CD), R522.2, R527.1
SD_CD: J501.9 (DET_B); also elsewhere on the board
SPICLK_SOC: R544.1; also elsewhere on the board
SPICS0_SOC: R540.1; also elsewhere on the board
SPID_SOC: R543.1; also elsewhere on the board
SPIHD_SOC: R545.1; also elsewhere on the board
SPIQ_SOC: R541.1; also elsewhere on the board
SPIWP_SOC: R542.1; also elsewhere on the board
SPK_N: J502.2; also elsewhere on the board
SPK_P: J502.1; also elsewhere on the board
UART0_RX: J503.3; also elsewhere on the board
UART0_TX: J503.5; also elsewhere on the board
VDD_SPI: C520.1, C521.1, C543.1, U506.8 (VCC); also elsewhere on the board
XTAL_N: C529.1, Y501.3; also elsewhere on the board
XTAL_P: C528.1, Y501.1; also elsewhere on the board

Notes on the sheet:
ESP32-S3、IMU、Flash、microSD 与调试（2/2）

Parts:
C204: 330n / U906 bypass; C204_Core; MPN 0603B334K500NT; LCSC C188679
C601: 100n / U601 VCC; C601_Core; MPN 0402B104K250NT; LCSC C56392
R600: 10k 1% / PG_PU; R600_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1002FT; LCSC C140215
R604: 100k / SD_EN_PD; R604_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R605: 100k / TOUCH_EN_PD; R605_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R606: 100k / EPD_EN_PD; R606_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R607: 100k / CHG_REQUEST_PD; R607_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R608: 100k / FUEL_PU; R608_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R609: 100k / BQ_INT_PU; R609_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R610: 100k / BQ_STAT_PU; R610_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R611: 100k / KEY_FN_PU; R611_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R612: 100k / SD_CD_PU; R612_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R613: 2.2k / I2C_SCL_PU A; R613_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K2201FT; LCSC C140192
R614: 2.2k / I2C_SDA_PU A; R614_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K2201FT; LCSC C140192
TP13: EXP_INT; TP13_Core; MPN NOT_A_PURCHASED_PART
TP14: EXP_INT / SHARED_IRQ; TP14_Core; MPN NOT_A_PURCHASED_PART
TP16: PG_3V3_MAIN; TP16_Core; MPN NOT_A_PURCHASED_PART
U601: XL9535; U601_Core; MPN XL9535; LCSC C561273

Connections:
3V3_AON: C204.1, C601.1, R600.2, R608.2, R609.2, R610.2, R611.2, R612.2, R613.2, R614.2, U601.24 (VCC_24); also elsewhere on the board
BQ_INT: R609.1, U601.10 (P06_10); also elsewhere on the board
BQ_PG: R600.1, U601.13 (P10_13); also elsewhere on the board
BQ_STAT: R610.1, U601.11 (P07_11); also elsewhere on the board
CHG_REQUEST: R607.1, U601.9 (P05_9); also elsewhere on the board
EN_3V3_EPD_LOGIC: R606.1, U601.6 (P02_6); also elsewhere on the board
EN_3V3_SD: R604.1, U601.4 (P00_4); also elsewhere on the board
EN_3V3_TOUCH: R605.1, U601.5 (P01_5); also elsewhere on the board
EN_VSYS_AUDIO: U601.7 (P03_7); also elsewhere on the board
EXP_INT: TP13.1 (1_1), TP14.1 (1_1), U601.1 (~INT_1); also elsewhere on the board
FL_PWM: U601.19 (P16_19); also elsewhere on the board
FUEL_GPOUT: R608.1, U601.8 (P04_8); also elsewhere on the board
GND: C204.2, C601.2, R604.2, R605.2, R606.2, R607.2, U601.2 (A1_2), U601.3 (A2_3), U601.12 (GND_12), U601.21 (A0_21); also elsewhere on the board
I2C_SCL: R613.1, U601.22 (SCL_22); also elsewhere on the board
I2C_SDA: R614.1, U601.23 (SDA_23); also elsewhere on the board
IMU_INT1: U601.15 (P12_15); also elsewhere on the board
KEY_FN: R611.1, U601.14 (P11_14)
P47_BUS_OE_N: U601.18 (P15); also elsewhere on the board
PG_3V3_MAIN: TP16.1 (1_1), U601.17 (P14_17); also elsewhere on the board
SD_CD: R612.1, U601.16 (P13_16); also elsewhere on the board
TOUCH_RST: U601.20 (P17_20); also elsewhere on the board

Notes on the sheet:
IO 扩展 XL9535

Parts:
C710: 100n/25V/0402; C710_Core; MPN 0402B104K250NT; LCSC C56392
C711: 100n/25V/0402; C711_Core; MPN 0402B104K250NT; LCSC C56392
R710: 22; R710_Core; MPN RC-02K22R0FT; LCSC C324769
R711: 22; R711_Core; MPN RC-02K22R0FT; LCSC C324769
R712: 22; R712_Core; MPN RC-02K22R0FT; LCSC C324769
R713: 22; R713_Core; MPN RC-02K22R0FT; LCSC C324769
R714: 22; R714_Core; MPN RC-02K22R0FT; LCSC C324769
R715: 22; R715_Core; MPN RC-02K22R0FT; LCSC C324769
R716: 22; R716_Core; MPN RC-02K22R0FT; LCSC C324769
R717: 22; R717_Core; MPN RC-02K22R0FT; LCSC C324769
R732: 10k; R732_Core; MPN RC-02K1002FT; LCSC C140215
U710: SGM330A-YTS/TR; U710_Core; MPN SGM330A-YTS/TR; LCSC C700205
U711: SGM330A-YTS/TR; U711_Core; MPN SGM330A-YTS/TR; LCSC C700205

Connections:
3V3_AON: C710.1, C711.1, U710.16 (VCC), U711.16 (VCC); also elsewhere on the board
GND: C710.2, C711.2, R732.2, U710.8 (GND), U711.8 (GND); also elsewhere on the board
P47_BUS_OE_N: R732.1, U710.15 (EN_N), U711.15 (EN_N); also elsewhere on the board
P47_BUS_SELECT: U710.1 (IN), U711.1 (IN); also elsewhere on the board
P47_D0: R710.2; also elsewhere on the board
P47_D0_SRC: R710.1, U710.3 (S20)
P47_D1: R711.2; also elsewhere on the board
P47_D1_SRC: R711.1, U710.13 (S23)
P47_D2: R712.2; also elsewhere on the board
P47_D2_SRC: R712.1, U710.6 (S21)
P47_D3: R713.2; also elsewhere on the board
P47_D3_SRC: R713.1, U710.10 (S22)
P47_D4: R714.2; also elsewhere on the board
P47_D4_SRC: R714.1, U711.10 (S22)
P47_D5: R715.2; also elsewhere on the board
P47_D5_SRC: R715.1, U711.3 (S20)
P47_D6: R716.2; also elsewhere on the board
P47_D6_SRC: R716.1, U711.6 (S21)
P47_D7: R717.2; also elsewhere on the board
P47_D7_SRC: R717.1, U711.13 (S23)
P47_MUX0: U710.4 (D0); also elsewhere on the board
P47_MUX1: U710.7 (D1); also elsewhere on the board
P47_MUX2: U711.7 (D1); also elsewhere on the board
P47_MUX3: U710.12 (D3); also elsewhere on the board
P47_MUX4: U711.4 (D0); also elsewhere on the board
P47_MUX5: U710.9 (D2); also elsewhere on the board
P47_MUX6: U711.9 (D2); also elsewhere on the board
P47_MUX7: U711.12 (D3); also elsewhere on the board
SDMMC_CLK: U711.2 (S10); also elsewhere on the board
SDMMC_CMD: U711.11 (S12); also elsewhere on the board
SDMMC_D0: U710.2 (S10); also elsewhere on the board
SDMMC_D1: U710.5 (S11); also elsewhere on the board
SDMMC_D2: U711.14 (S13); also elsewhere on the board
SDMMC_D3: U711.5 (S11); also elsewhere on the board
UART0_RX: U710.14 (S13); also elsewhere on the board
UART0_TX: U710.11 (S12); also elsewhere on the board

Notes on the sheet:
屏幕数据 / microSD 多路开关

Schematic: Single-epd1.kicad_sch, 墨水屏电源 SY7636A 与面板、触摸、前光接口（1/2）

Parts:
C801: 10u/10V/0805; C801_Display; MPN 0805B106K100NT; LCSC C90544
C802: 4.7u/25V/0805; C802_Display; MPN 0805B475K250NT; LCSC C2885646
C803: 10u/10V/0805; C803_Display; MPN 0805B106K100NT; LCSC C90544
C804: 4.7u/25V/0805; C804_Display; MPN 0805B475K250NT; LCSC C2885646
C805: 4.7u/25V/0805; C805_Display; MPN 0805B475K250NT; LCSC C2885646
C806: 4.7u/25V/0805; C806_Display; MPN 0805B475K250NT; LCSC C2885646
C807: 1u/50V/0805; C807_Display; MPN 0805B105K500NT; LCSC C215803
C808: 47n/50V/0805; C808_Display; MPN 0805B473K500NT; LCSC C1745
C810: 1u/50V/0805; C810_Display; MPN 0805B105K500NT; LCSC C215803
C811: 47n/50V/0805; C811_Display; MPN 0805B473K500NT; LCSC C1745
C813: 4.7u/25V/0805; C813_Display; MPN 0805B475K250NT; LCSC C2885646
C814: 4.7u/25V/0805; C814_Display; MPN 0805B475K250NT; LCSC C2885646
C815: 100n/25V/0402; C815_Display; MPN 0402B104K250NT; LCSC C56392
C816: 10u/10V/0805; C816_Display; MPN 0805B106K100NT; LCSC C90544
C817: 100n/25V/0402; C817_Display; MPN 0402B104K250NT; LCSC C56392
D801: MBR0530 / PEAK REVIEW; D801_Display; MPN MBR0530; LCSC C77336
D802: MBR0530 / PEAK REVIEW; D802_Display; MPN MBR0530; LCSC C77336
L801: 4.7uH / MWSA0618S-4R7MT; L801_Display; MPN MWSA0618S-4R7MT; LCSC C408421
L802: 4.7uH / MWSA0618S-4R7MT; L802_Display; MPN MWSA0618S-4R7MT; LCSC C408421
R801: 442k/0.1%; R801_Display; MPN THC02H4423BT
R802: 21k/0.1%; R802_Display; MPN THC02H2102BT
R803: 750k/0.1%; R803_Display; MPN THC02H7503BT
R804: 59k/0.1%; R804_Display; MPN THC02H5902BT
R805: 7.5k/1%; R805_Display; MPN RC-02K7501FT; LCSC C140131
R806: 36k/1%; R806_Display; MPN RC-02K3602FT; LCSC C324808
R807: 10k; R807_Display; MPN RC-02K1002FT; LCSC C140215
R808: 100k; R808_Display; MPN RC-02K1003FT; LCSC C140219
R809: 100k; R809_Display; MPN RC-02K1003FT; LCSC C140219
R813: 1k; R813_Display; MPN RC-02K1001FT; LCSC C140197
TH801: 10k NTC / CURVE TO QUALIFY; TH801_Display; MPN CMKD103F3380HANT
TP712: P47_PGOOD; TP712_Core; MPN NOT_A_PURCHASED_PART
TP803: P47_VPOS; TP803_Display; MPN NOT_A_PURCHASED_PART
TP805: P47_VCOM; TP805_Display; MPN NOT_A_PURCHASED_PART
U810: SY7636ARMC; U810_Display; MPN SY7636ARMC
U811: XL9535 / ADDRESS0x21; U811_Display; MPN XL9535; LCSC C561273

Connections:
3V3_AON: C817.1, R807.2, U811.21 (A0_21), U811.24 (VCC_24); also elsewhere on the board
EXP_INT: U811.1 (~INT_1); also elsewhere on the board
GND: C801.2, C802.2, C803.2, C804.2, C805.2, C806.2, C807.2, C810.2, C813.2, C814.2, C815.2, C816.2, C817.2, L802.2, R802.2, R806.2, R808.2, R809.2, TH801.2, U810.8 (AGND1), U810.32 (PGND2), U810.41 (PGND1), U810.48 (AGND2), U811.2 (A1_2), U811.3 (A2_3), U811.12 (GND_12); also elsewhere on the board
HW_ARM_GPIO: R813.1, U811.14 (P11_14); also elsewhere on the board
I2C_SCL: U810.17 (SCL), U811.22 (SCL_22); also elsewhere on the board
I2C_SDA: U810.18 (SDA), U811.23 (SDA_23); also elsewhere on the board
P47_HV_EN: R808.1, R813.2, U810.21 (EN), U811.4 (P00_ENABLE_MONITOR)
P47_MODE: U811.6 (P02_6); also elsewhere on the board
P47_PGOOD: R807.1, TP712.1, U810.23 (PGOOD), U811.13 (P10_13)
P47_PUMP_NEG: C811.1; also elsewhere on the board
P47_PUMP_POS: C808.1; also elsewhere on the board
P47_TS: R805.2, R806.1, TH801.1, U810.47 (TS)
P47_VCC: C814.1, U810.7 (VCC)
P47_VCOM: C813.1, TP805.1, U810.15 (VCOM); also elsewhere on the board
P47_VCOM_EN: R809.1, U810.12 (VCOM_EN), U811.5 (P01_5)
P47_VEE_BASE: C810.1, U810.30 (VEE_D); also elsewhere on the board
P47_VEE_DRV: C811.2, U810.28 (VEE_DRV)
P47_VEE_FB: R803.2, R804.1, U810.31 (VEE_FB)
P47_VGH: R801.1, U810.35 (VDDH_DIS); also elsewhere on the board
P47_VGH_BASE: C807.1, U810.34 (VDDH_D); also elsewhere on the board
P47_VGH_DRV: C808.2, U810.36 (VDDH_DRV)
P47_VGH_FB: R801.2, R802.1, U810.33 (VDDH_FB)
P47_VGL: R803.1; also elsewhere on the board
P47_VN: C804.1, D802.2 (A), U810.4 (VNEG_IN), U810.26 (VN)
P47_VNEG: C806.1, U810.3 (VNEG); also elsewhere on the board
P47_VN_LX: D802.1 (K), L802.1, U810.25 (VN_LX)
P47_VP: C802.1, D801.1 (K), U810.42 (VP)
P47_VPOS: C805.1, TP803.1, U810.44 (VPOS); also elsewhere on the board
P47_VP_LX: D801.2 (A), L801.2, U810.40 (VP_LX)
P47_VREF: C815.1, R804.2, R805.1, U810.1 (VREF)
P47_XOE: U811.7 (P03_7); also elsewhere on the board
VSYS_RAW: C801.1, C803.1, C816.1, L801.1, U810.10 (VIN), U810.24 (VN_IN); also elsewhere on the board

Notes on the sheet:
墨水屏电源 SY7636A 与面板、触摸、前光接口（1/2）
