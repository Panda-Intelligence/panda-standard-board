# Repository Panda-Intelligence/panda-standard-board

File README.md:

# Current development entry — Panda Standard (E0.2 r26 / v0.1.1)

The current product is the **Panda Standard 4.7-inch parallel E0470A01-family single-board
engineering design**, with a replaceable 2050mAh LCO battery pack (`323576`) and a
finished-device maximum thickness of 7mm, including positive tolerances.
The exact pack identity, complete panel suffix/assembly and finished tolerance
stack remain unaccepted. A CAD candidate is **NOT FOR FABRICATION OR POWER**.

Start with [the current Single Unified PCB handoff](hardware/pico47/E02-R25-SINGLE-UNIFIED-PCB-20261029.md)
and [the Panda Standard source/build guide](hardware/pico47/README.md). Source code is
under `hardware/pico47/`; each finished single-board release (`Single.kicad_pcb` and its
native KiCad project/libraries) is committed under its version-named directory:
- [`hardware/pico47/v0.1.0/`](hardware/pico47/v0.1.0/) (`R25` full-rectangle 4-layer baseline)
- [`hardware/pico47/v0.1.1/`](hardware/pico47/v0.1.1/) (`R26` L-step 4-layer board with `X = 38.0 mm` battery bay clearance & Option 1 upper-right support bay)
Temporary generated rebuild reports and manufacturing archives remain in ignored `.work/`
or the external `panda-board-deliverables` directory.
The older Split-C1 / Product-D / Thin7 designs below are electrical donors or
historical experiments, not the current product or approval to export/order it.

Current r24 native checkpoint: **Core 16 opens; Display 0 opens; DRC errors,
warnings, parity and ERC are zero**. MUX0 is connected, while the remaining
non-ground routing is still unfinished. All 237 ground pads retain their reference
connections. **16 non-ground unconnected items remain; not for fabrication or
power.** The dated handoff records actual source replay, delivery archives and
engineering limits. Continue with
`capture_pico47_checkpoint.py --require-complete-ground`.

Run source regressions without EDA or manufacturing side effects:

```sh
python3 -m unittest discover -s hardware/pico47 -p 'test_*.py'
python3 -m unittest discover -s hardware/thin18-compact -p 'test_*.py'
```

Capture a continuation with `hardware/pico47/capture_pico47_checkpoint.py` only
after native review. It checks fresh DRC/ERC, exact rules/geometry/library
bindings and every previous native pad group. Missing evidence, lost connections
or increased opens/warnings reject the checkpoint. It never grants fabrication
or physical qualification, including when native counts happen to reach zero.

---

# Panda Standard Board

Open hardware design sources and engineering documentation for the **Panda Standard Board**, maintained by Panda Intelligence.

## Historical Split-C1 electrical donor

The historical electrical donor is the populated **Core-C1 96 x 68 mm / 4-layer** plus
**Display-C1 45 x 36 mm / 2-layer** design already split and routed on main.
Start with [Split-C1 handoff](hardware/thin18-compact/SPLIT-C1-HANDOFF.md) and the
[PG/PSEL functional migration](hardware/thin18-compact/SPLIT-C1-POWER-INTEGRITY.md).
Do not replace it with Thin7/portrait-R2 experimental CAD merely because an
experiment has a newer timestamp. Thin7 remains a separate, incomplete 7-mm
mechanical target and is not claimed by the Split-C1 bench prototype.

Inspect the historical pipeline without generating manufacturing data:

```sh
python3 hardware/thin18-compact/release_split_c1.py --target split-c1 --plan
```

Bare-board CAM/DFM, accepted PCBA supply and physical EVT are separate gates.
The new supervisor is a mainland part, but its exact assembly code/receipt is
not yet confirmed. No production qualification or actual purchase is implied.

## Historical published Thin18 baseline

The earlier published integrated-board engineering baseline was:

- **Board:** Thin18 domestic EVT
- **PCB checkpoint:** `routing142`
- **PCB SHA-256:** `ccc19c5402f633638ed72e7c94a92375684037a1f9c04f63072dc58f86c16071`
- **KiCad validation:** 0 DRC violations, 0 unconnected items, 0 schematic-parity errors; ERC 0
- **Status:** engineering / EVT — **not a manufacturing release**

The baseline includes the current right-side microSD access geometry. Manufacturing, assembly, SI/PI, RF, thermal, tolerance-stack and physical EVT qualification remain separate release gates.

## Repository layout

```text
hardware/
  thin18/
    routing142/        Current KiCad engineering baseline and machine-readable verification evidence
docs/
  design/              Electrical architecture, interfaces, power tree, constraints and design rules
  verification/        ERC/layout/fabrication-readiness engineering reviews
  mechanical/          Board/mechanical interface review notes
LICENSES/
```

## Opening the historical donor design

The design was validated with **KiCad 10.0.5**. Open the complete project under:

```text
hardware/thin18-compact/core-c1-96x68-split/eda/core/PANDA-STD-CORE-EVT/PANDA-THIN16/
hardware/thin18-compact/display-c1-45x36-production-bom/
```

Project-local symbol and footprint libraries are included where the design depends on them.

## Product visualization

Explore the [interactive Thin18 routing142 assembly model](hardware/thin18/routing142/visualization/Panda-thin18-routing142-exploded.html) or watch the [exploded-view video on YouTube](https://youtu.be/T_Nb8tvqas8).

The model is an engineering visualization for design communication. Mechanical fit and manufacturing readiness require separate validation.

## Verification boundary

A clean KiCad DRC/ERC result means the design database is internally consistent. It does **not** establish production qualification, regulatory compliance, component derating, RF performance, thermal margin, assembly yield or mechanical fit of real production parts.

Use tagged manufacturing releases, when available, for fabrication rather than assuming the newest engineering checkpoint is production-ready.

## Licensing

Hardware design sources: **CERN-OHL-S-2.0**.

Documentation: **CC BY-SA 4.0**, unless otherwise noted.

Third-party component models, symbols, footprints, manufacturer names and trademarks retain their respective rights and licensing terms.

## Split-C1 executable control follow-up

[Portable bench-control core](firmware/split_c1/README.md) implements tested
XL9535/SGM41513/SGM37601 sequencing and a read-only QMI8658A identity probe.
Host tests and native pin/address binding checks run in the explicit Split-C1
export pipeline. This is not product-firmware integration or physical EVT.
The [hardware-finish ECO](hardware/thin18-compact/SPLIT-C1-HARDWARE-FINISH.md) adds default-off charge authorization and a native GPIO2 shutdown path.
Read the updated control binding before using any older firmware. Physical EVT and accepted assembly supply remain separate gates.

## Current fabrication entry

The combined review package contains a generated `START-HERE.md`; use its
separate Core/Display Gerber paths and source hashes. The
[fabrication handoff](hardware/thin18-compact/JLC-PROTOTYPE-HANDOFF.md) now matches
the native four-layer35um Core copper construction and ENIG/green-mask selection.
C301 now has checked1.9mm round PTHs instead of short slots; the actual stackup
and assembly process still need CAM acceptance.
Native DRC/DFM success is not automatic fabrication/PCBA order approval.

## Split-C1 SMT process selection

The native [assembly-process auditor](hardware/thin18-compact/audit_split_c1_assembly_process.py)
and its tests now run before fabrication export. Core contains13 drilled vias
intersecting SMT copper lands; its order must explicitly include epoxy filling
and copper capping for the generated list. This is distinct from soldermask
tenting/plugging and must not fill component lead holes or slots. The generated
prototype package includes ASSEMBLY-PROCESS.md and per-board VIA-IN-PAD.csv,
bound to the saved PCB and checked against Excellon drill hits. Small WLCSP and
connector lands retain ENIG and need assembler stencil/process confirmation.
No source copper is changed by this audit; supplier acceptance is still required.

## KiCad design hardware/pico47/v0.3.1/Panda426-v031.kicad_pcb

File hardware/pico47/v0.3.1/README.md:

# Panda Standard 4.26 — main board v0.3.1 / E13

- **Board**: `Panda426-v031.kicad_pcb`. The v0.2.8 board (63 × 48 mm, 4 layers, 0.8 mm) with the display block
  exchanged for a 4.26" 800 × 480 SPI panel module with front light and touch. See the
  [E13 note](../E13-V031-426-FRONTLIGHT-TOUCH-20261118.md); the display circuit is described in the
  [E08 note](../E08-V030-426-SPI-VARIANT-20261117.md).
- **Replaces v0.3.0**, which had a reversed front-light pin map, both small connectors where the tails cannot reach,
  and the three circuit faults of v0.2.4.
- **Changes from v0.2.8**:
  - Removed: SY7636A block, 16-bit panel bus, 40-pin connector J820.
  - Added: 24-pin connector J830 on the USB-C axis and the panel boost stage (L831, Q831, D831–D833).
  - J804 (front light) at (12.57, 110.95), turned 180°, for a Z-folded tail; R921 15 Ω (13.3 mA).
  - J803 (touch, FT6336U) at (51.44, 93.45); U506, C543, C523, C513 and FID3 moved for the two connectors.
  - Panel signals on GPIO4–9: BUSY, RST, DC, CS, SCK, MOSI.
- **Schematic**: `Panda426-v031.kicad_sch` (index) + sheets, generated from the netlist.
- **Native checks** (KiCad 10.0.7, in this directory): ERC 0. DRC 0 violations, 0 unconnected, 0 schematic parity
  (`--severity-all`).
- **Status**: `manufacturing_release = false`. The touch-tail pin order is not confirmed; open items are in §6 of
  the E13 note. No order pack was made.

## Build path

`../v031/build_v031.sh` rebuilds this directory from `../v0.2.8/` (work files in `.work/v031`):

1. `make_netlist_v020.py` with `PANDA47_VARIANT=v031` → netlist (154 parts including test pads).
2. `v031/eco_strip.py`, `v031/prune_stubs.py`: remove the old display block and its feed branches.
3. `v031/eco_display.py`: J830 and the boost stage with hand copper. `v031/eco_conn.py`: J803, J804 and the parts
   moved for them.
4. Grid router (`router_v020.py` + `apply_router_v020.py`) with `v031/spec_display.json`.
5. `v031/finish_v031.py`, `v031/trim_dangling.py`, `v023/widen_v023.py`, `silk_v020.py`, `info_silk_v02x.py` with
   `v031/v031_silk.json`.
6. `build_v020_sch.py`, `sync_board_sch_v020.py`, `set_fields_v020.py`, then ERC and DRC.

Board: 4 copper layers, 63.0 x 48.0 mm, 159 parts (4 on the bottom side), 93 nets.

Parts:
C201: 47n / CBOOT; C201_Core
C202: 1u / VBUS; C202_Core
C203: 10u / PMID; C_0805_2012Metric
C205: 4.7u / REGN; C205_Core
C206: 10u / BAT; C206_Core
C207: 22u / CSYS1; C_0603_1608Metric
C208: 22u / CSYS2; C_0603_1608Metric
C209: 1u / VBUS; C_0402_1005Metric
C302: 100n / RTC VDD; C302_Core
C303: 1u / BQ BAT; C303_Core
C304: 2.2u / BQ VDD; C304_Core
C305: 22pF / RTC OSCI; C_0402_1005Metric
C401: 22u / VIN; C401_Core
C402: 22u / VOUT; C402_Core
C403: 22u / VOUT; C403_Core
C404: 22pF; C_0402_1005Metric
C501: 22u / ESP32; C501_Core
C502: 100n / ESP32; C502_Core
C503: 100n / VDD_IO; C503_Core
C504: 100n / VDD; C504_Core
C505: 100n / AUDIO_VDD; C505_Core
C506: 10u / AUDIO_VDD; C506_Core
C508: 1u / U402 VIN; C508_Core
C510: 1u / CHIP_PU; C_0402_1005Metric
C512: 100n / SD VDD; C512_Core
C513: 10u / SD VDD; C513_Core
C520: 100n; C520_Core
C521: 1u; C521_Core
C522: 100n; C522_Core
C523: 100n; C523_Core
C524: 100n; C524_Core
C525: 22u / local RF supply; C_0603_1608Metric
C526: 100n; C526_Core
C527: 1u; C527_Core
C528: 18p / crystal; C528_Core
C529: 18p / crystal; C529_Core
C530: 0.8p / RF; C530_Core
C531: 0.8p / RF; C531_Core
C532: 1uF 10V X5R / U404 COUT; C532_Core
C533: 1uF 10V X5R / U402 COUT; C533_Core
C539: 100nF 25V X7R / U503 VDD_IO; C539_Core
C543: 100nF 25V X7R / U506 VCC; C543_Core
C601: 100n / U601 VCC; C601_Core
C831, C832, C833, C834, C835, C836, C837: 4.7u/25V/0603; C_0603_1608Metric
C838: 1u/50V/0603; C_0603_1608Metric
C839, C840: 1u/25V/0402; C_0402_1005Metric
C903: 1u / CW2217 VCELL; C903_Core
C920: 4.7uF 16V X7R / FL_CIN; C920_Core
C923: 4.7uF 50V X5R / FL_COUT; C_0805_2012Metric
D201: LRC8804DT1G; D201_Core
D202: LESD8D5.0T5G; D202_Core
D203: Green side-view LED; LED_SideView_TJ-S1706
D831, D832, D833: 1N5819WS; D_SOD-323
D905: B5819W SL / FL_RECT; D905_Core
FID1, FID2, FID3: Fiducial; Fiducial_1mm_Mask2mm
H2, H3: M1.6 SMT nut; SMTSO_M1.6_L1
J201: U22401-23 / MID-MOUNT; J201_Core
J302: WAFER-ACH1.2-3PWB / pack; JST_ACH_BM03B-ACHSS-GAN-ETF_1x03-1MP_P1.20mm_Vertical
J501: TF-019 / microSD; TF_Hanbo_TF-019
J502: SOLDER LANDING / J502; J502_Core
J507: MHF4 receptacle; MHF4_KH-IPEX4-2020
J803: X05A10H06G; J803_Core
J804: X05A10H06G; J804_Core
J830: X05A10L24G / 4.26-inch SPI panel; FPC_XKB_X05A10L24G
L401: 1uH; L_Murata_DFE201610P
L402: 1uH; L_Changjiang_FNR4012S
L506: 24nH / crystal; L506_Core
L507: 2nH / RF supply; L507_Core
L508: 2nH / RF match; L508_Core
L831: 47uH; L_Changjiang_FNR4012S
L905: 10uH / FL_BOOST; L905_Core
MH1: Locating hole; LocHole_NPTH_1.2
MH2: Locating hole; LocSlot_NPTH_1.2x1.6
Q831: WST3052; SOT-323_SC-70
Q901: LBSS138DW1T1G; SOT-363_SC-70-6
R201: 5.6k / PSEL low leg; R201_Core
R204: 1.2k / REGN to PSEL; R204_Core
R206: 5.1k ±5% / USB-C Rd; R206_Core
R207: 5.1k ±5% / USB-C Rd; R207_Core
R208: 1k; R_0402_1005Metric
R306: 10m / CW2217 SHUNT; R306_Core
R401, R528, R602: 100k; R_0402_1005Metric
R402: 22.1k; R_0402_1005Metric
R501: 100k / IMU_INT1; R501_Core
R502: 100k / EXP_INT_PU; R502_Core
R510: 10k / CHIP_PU; R510_Core
R511: 10k / GPIO0; R511_Core
R512: 10k / GPIO3; R512_Core
R513: 10k / GPIO46; R513_Core
R515: 100k / FL_PWM_PD; R_0402_1005Metric
R516: 100k / AUDIO_EN_PD; R_0402_1005Metric
R523: 10k / SD pull-up; R523_Core
R524: 10k / SD pull-up; R524_Core
R525: 10k / SD pull-up; R525_Core
R526: 10k / SD pull-up; R526_Core
R527: 10k / SD pull-up; R527_Core
R529: 22; R529_Core
R530: 22; R530_Core
R601: 100k / FL_HWEN_PD; R601_Core
R604: 100k / SD_EN_PD; R604_Core
R608: 100k / FUEL_PU; R608_Core
R609: 100k / BQ_INT_PU; R609_Core
R612: 100k / SD_CD_PU; R612_Core
R613: 2.2k / I2C_SCL_PU A; R613_Core
R614: 2.2k / I2C_SDA_PU A; R614_Core
R615: 5.23k; R615_Core
R616: 30.1k; R616_Core
R731: 10k; R731_Core
R831: 2.2R 1%; R_0603_1608Metric
R832: 1M; R_0402_1005Metric
R903: 100R / CW2217 VDD; R903_Core
R904: 100R / CW2217 VCELL; R904_Core
R910: 10k / TOUCH_INT_PU; R910_Core
R911: 10k / TOUCH_RST_PU; R911_Core
R921: 15R 1%; R_0402_1005Metric
SW201: TS-1186E-B-B; SW201_Core
SW202: TS-1186E-B-B; SW202_Core
TP1: VBUS_USB; TP1_Core
TP2: VSYS_RAW; TP2_Core
TP3: 3V3_AON; TP3_Core
TP4: BAT+; TP4_Core
TP5: FL_VOUT; TP11_Core
TP6: 3V3_SD; TP801_Display
TP11: I2C_SCL; TP11_Core
TP12: I2C_SDA; TP12_Core
TP18: CHIP_PU; TP18_Core
TP19: GPIO0 / BOOT; TP18_Core
TP801: EPD_PREVGH; TP801_Display
TP802: EPD_PREVGL; TP802_Display
TP803: EPD_BUSY; TP803_Display
TPG1: GND; TPG1_Core
TPG2: GND; TP11_Core
U302: BM8563EMA; MSOP-8_3x3mm_P0.65mm
U402: SGM2578YG/TR; U402_Core
U501: ESP32-S3R8; U501_Core
U503: SC7A20HTR; LGA-12_2x2mm_P0.5mm
U506: GD25Q128EWIGR; WSON-8-1EP_6x5mm_P1.27mm_EP3.4x4mm
U601: XL9535QF24; QFN-24-1EP_4x4mm_P0.5mm_EP2.7x2.7mm
U901: SGM41513YTQF24G/TR; U901_Core
U902: SY8089A1AAC; SOT-23-5
U903: CW2217BAAD; U903_Core
U904: NS4168; U904_Core
U905: SGM3732YTN6G/TR; TSOT-23-6
Y301: 32.768kHz 12.5pF; Crystal_SMD_3215-2Pin_3.2x1.5mm
Y501: 40MHz / 12pF; Y501_Core

Connections:
3V3_AON: C302.1, C402.1, C403.1, C404.1, C501.1, C502.1, C503.1, C504.1, C508.1, C522.1, C523.1, C526.1, C527.1, C532.1, C539.1, C601.1, C831.1, C840.1, J803.2, J830.15, J830.16, L401.2, L507.1, L831.1, R401.1, R502.2, R510.1, R511.1, R528.1, R608.2, R609.2, R612.2, R613.2, R614.2, R910.1, R911.1, TP3.1, U302.8, U402.A2, U501.20, U501.46, U501.55, U501.56, U503.3, U503.7, U503.10, U601.21
3V3_RF: C524.1, C525.1, L507.2, U501.2, U501.3
3V3_SD: C512.1, C513.1, C533.1, J501.4, R523.2, R524.2, R525.2, R526.2, R527.2, TP6.1, U402.A1
AUDIO_EN: R516.1, U601.7, U904.1
BAT_CONN_P: J302.1, R306.1, R904.1, TP4.1, U903.8
BAT_PACKP: C206.1, C303.1, R306.2, R903.1, U901.13, U901.14, U903.7
BQ_INT: R609.1, U601.12, U901.7
BQ_QON: SW202.1, U901.12
BQ_TS: J302.3, R615.2, R616.1, U901.11
BUCK_FB: C404.2, R401.2, R402.1, U902.5
BUCK_LX: L401.1, U902.3
CHG_LED_A: D203.2, R208.2
CHG_STAT: D203.1, U901.4
CHIP_PU_MCU: C510.1, R510.2, TP18.1, U501.4
EN_3V3_SD: R604.1, U402.B2, U601.1
EPD_BUSY: J830.9, TP803.1, U501.9
EPD_CS: J830.12, U501.12
EPD_DC: J830.11, U501.11
EPD_GDR: J830.2, Q831.1, R832.1
EPD_LX: C832.1, D831.2, L831.2, Q831.3
EPD_MOSI: J830.14, U501.14
EPD_PREVGH: C833.1, D831.1, J830.21, TP801.1
EPD_PREVGL: C834.1, D832.2, J830.23, TP802.1
EPD_PUMP: C832.2, D832.1, D833.2
EPD_RESE: J830.3, Q831.2, R831.1
EPD_RST: J830.10, U501.10
EPD_SCK: J830.13, U501.13
EPD_VCOM: C838.1, J830.24
EPD_VDD: C839.1, J830.18
EPD_VSH1: C835.1, J830.20
EPD_VSH2: C836.1, J830.5
EPD_VSL: C837.1, J830.22
EXP_INT: R502.1, U302.3, U501.6, U601.22
FLASH_CLK: U501.33, U506.6
FLASH_CS: U501.32, U506.1
FLASH_D: U501.35, U506.5
FLASH_HD: U501.30, U506.7
FLASH_Q: U501.34, U506.2
FLASH_WP: U501.31, U506.3
FL_C_EN: Q901.5, R602.1, U601.16
FL_C_N: J804.5, Q901.3
FL_FB: Q901.1, Q901.4, R921.1, U905.3
FL_PWM: R515.1, U501.7, U905.4
FL_SW: D905.2, L905.2, U905.1
FL_VOUT: C923.1, D905.1, J804.2, J804.6, TP5.1, U905.5
FL_W_EN: Q901.2, R601.1, U601.6
FL_W_N: J804.1, Q901.6
FUEL_GPOUT: R608.1, U601.13, U903.1
FUEL_VCELL: C903.1, R904.2, U903.4
FUEL_VDD: C304.1, R903.2, U903.3
GND: C202.2, C203.2, C205.2, C206.2, C207.2, C208.2, C209.2, C302.2, C303.2, C304.2, C305.2, C401.2, C402.2, C403.2, C501.2, C502.2, C503.2, C504.2, C505.2, C506.2, C508.2, C510.2, C512.2, C513.2, C520.2, C521.2, C522.2, C523.2, C524.2, C525.2, C526.2, C527.2, C528.2, C529.2, C530.2, C531.2, C532.2, C533.2, C539.2, C543.2, C601.2, C831.2, C833.2, C834.2, C835.2, C836.2, C837.2, C838.2, C839.2, C840.2, C903.2, C920.2, C923.2, D201.3, D201.8, D202.2, D833.1, H2.1, H3.1, J201.A1, J201.A12, J201.B1, J201.B12, J201.SH, J302.2, J302.MP, J501.6, J501.SH, J507.2, J803.1, J830.8, J830.17, J830.MP, R201.2, R206.1, R207.1, R402.2, R501.2, R512.2, R513.2, R515.2, R516.2, R601.2, R602.2, R604.2, R616.2, R731.2, R831.2, R832.2, R921.2, SW201.2, SW202.2, TPG1.1, TPG2.1, U302.4, U402.B1, U501.57, U503.4, U503.8, U503.9, U506.4, U601.9, U601.18, U601.23, U601.24, U601.25, U901.9, U901.17, U901.18, U901.25, U902.2, U903.6, U903.13, U904.7, U904.9, U905.2, Y501.2, Y501.4
GPIO3_STRAP: R512.1, U501.8
GPIO45_STRAP: R731.1, U501.51
GPIO46_STRAP: R513.1, U501.52
I2C_SCL: J803.6, R613.1, TP11.1, U302.6, U501.45, U503.12, U601.19, U901.5, U903.11
I2C_SDA: J803.5, R614.1, TP12.1, U302.5, U501.44, U503.2, U601.20, U901.6, U903.10
I2S_BCLK: R511.2, TP19.1, U501.5, U904.3
I2S_DIN: U501.49, U904.4
I2S_LRCLK: U501.47, U904.2
IMU_INT1: R501.1, U503.5, U601.14
KEY_POWER: R528.2, SW201.1, U601.17
LNA_IN: C530.1, L508.1, U501.1
RF_ANT: C531.1, J507.1, L508.2
RTC_OSCI: C305.1, U302.1, Y301.1
RTC_OSCO: U302.2, Y301.2
SD_CD: J501.9, R612.1, U601.15
SD_CLK: J501.5, U501.43
SD_CMD: J501.3, R523.1, U501.48
SD_D0: J501.7, R524.1, U501.50
SD_D1: J501.8, R525.1
SD_D2: J501.1, R526.1
SD_D3: J501.2, R527.1
SGM41513_BTST: C201.1, U901.21
SGM41513_PMID: C203.1, U901.23
SGM41513_PSEL: R201.1, R204.1, U901.2
SGM41513_REGN: C205.1, R204.2, R615.1, U901.22
SGM41513_SW: C201.2, L402.1, U901.19, U901.20
SPK_N: J502.2, U904.5
SPK_P: J502.1, U904.8
TOUCH_INT: J803.4, R910.2, U601.10
TOUCH_RST: J803.3, R911.2, U601.8
USB_CC1: D201.4, J201.A5, R206.2
USB_CC2: D201.5, J201.B5, R207.2
USB_DM: D201.2, J201.A7, J201.B7, R530.1
USB_DM_MCU: R530.2, U501.25
USB_DP: D201.1, J201.A6, J201.B6, R529.1
USB_DP_MCU: R529.2, U501.26
VBUS_USB: C202.1, C209.1, D202.1, J201.A4, J201.A9, J201.B4, J201.B9, TP1.1, U901.1, U901.24
VDD_SPI: C520.1, C521.1, C543.1, U501.29, U506.8
VSYS_RAW: C207.1, C208.1, C401.1, C505.1, C506.1, C920.1, L402.2, L905.1, R208.1, TP2.1, U901.15, U901.16, U902.1, U902.4, U904.6, U905.6
XTAL_N: C529.1, U501.53, Y501.3
XTAL_P: C528.1, L506.2, Y501.1
XTAL_P_SOC: L506.1, U501.54

## KiCad design hardware/pico47/v0.1.2/Single.kicad_pcb

File hardware/pico47/v0.1.2/README.md:

# Panda Standard — Single 4-Layer PCB (`v0.1.2` / `R49`)

- **Board**: `Single.kicad_pcb`, 71.0 × 99.0 mm L-step four-layer board, R49 (= R48 layout + front-light supply fix).
- **Schematic**: `Single.kicad_sch` (index page) + 11 A4/A3 sheets `Single-*.kicad_sch`, drawn in the usual style (see below). Same 265 parts, pins and 255 nets as the R49 netlist-style source.
- **Native checks** (KiCad 10.0.7, this directory alone): DRC 0 errors / 0 warnings / 0 unconnected / 0 schematic parity, ERC 0.
- **Rebuild**: `python3 build_pico47_single_r49.py --output <new dir under .work>` (KiCad Python) replays R26 → R48 → R49, writes this schematic and the JLC order pack; `--netlist-style-schematic` keeps the one-label-per-pin form.
- **Status**: `manufacturing_release = false`. Ordering prerequisites are listed in [R49 note](../E02-R49-FRONTLIGHT-SUPPLY-20261106.md) (46 Type VII via-in-pad CAM confirmation, current 13 pending SMT parts, BT301 post-SMT). The 2026-11-08 exact-MPN catalog metadata ECO is recorded in [R49 SMT catalog cleanup](../E02-R49-SMT-CATALOG-CLEANUP-20261108.md); the original R49 pending list was 21 parts and no electrical substitution was made.

## Changes vs. `v0.1.1`

1. R27–R48 layout revisions (see `../E02-R27-LAYOUT-FIXES-20261031.md` … `../E02-R48-XSTL-AND-CKV-BRIDGES-20261103.md`).
2. R49: the front-light boost input `VSYS_FL_IN` (L905 / R920 / C920) had no supply after the board merge; it now joins `VSYS_RAW` via a 0.40 mm, 29 mm link.
3. The schematic is redrawn by `../readable_schematic.py` as a hierarchical design:

| Sheet | Content |
|---|---|
| `USB_Input` | J201 USB-C, CC resistors, D201 / D202 ESD |
| `Battery_RTC` | J301 / J302 battery landings, R306 sense, U302 SD3078 RTC, BT301 |
| `Load_Switches` | U402–U405 SGM2578 rails |
| `MCU_1`, `MCU_2` | U501 ESP32-S3 with straps and bypass, U503 IMU, series resistors; U506 Flash, J501 microSD, J503 debug, Y501 |
| `IO_Expander` | U601 XL9535 and its pull resistors |
| `Panel_SD_Mux` | U710 / U711 SGM330A and their series resistors |
| `EPD_PMIC_1`, `EPD_PMIC_2` | U810 SY7636A, U811 expander, rectifiers; J820 panel, J803 touch, J804 front light, D803 / D804 charge pumps |
| `Charger_Power_1`, `_2` | U901 charger, U902 buck-boost, U903 gauge, U904 audio, U905 front light; U906 reset, U907 protection, Q907 / Q908 |

ICs and connectors are boxes with supply pins on top, ground pins at the bottom and signal pins on both sides; resistors, capacitors, inductors, diodes, the crystal, MOSFETs, buttons, the coin cell and test points use the KiCad standard-library drawings. A part with one end on ground or a supply hangs off the pin it serves (the owner is the nearest same-net pin on the PCB); decoupling groups share a supply bar; series parts sit in a column with a label at each end. Connections between parts are global labels, supplies are power symbols, unused pins carry a no-connect flag. Two power flags (`3V3_TOUCH`, `3V3_EPD_LOGIC`) are schematic-only ERC drivers.

The visible `Spec` field shows the part of `Value` before “/” (for example `100nF 25V X7R`); the full `Value` is unchanged and hidden. `Spec` is also on every footprint as a hidden Fab-layer field so the schematic-parity check stays at zero; copper, pads, positions and the Gerbers are unchanged. The build aborts if the regenerated netlist differs in any pin set or net name.

## Importing into EasyEDA Pro (嘉立创EDA专业版)

Import the project zip (all files at its root) with *File → Import → KiCad*. EasyEDA Pro documents KiCad import for versions below 10.0. The schematic files are written in the KiCad 9 format (`20250114`); the board is KiCad 10 (`20260206`), so the board import may be refused; copper zones are always rebuilt on import and must be re-checked. Fabrication itself only needs the Gerber / BOM / CPL from the order pack.

Notes on the sheet:
Panda Standard 4.7 Single 主板原理图（v0.1.2 / R49）
各页之间以同名全局标签与电源符号相连；网表与 R49 PCB 完全一致。
USB-C 接口与 ESD 防护
电池接口与 RTC（SD3078）
分路负载开关 SGM2578
ESP32-S3、IMU、Flash、microSD 与调试（1/2）
ESP32-S3、IMU、Flash、microSD 与调试（2/2）
IO 扩展 XL9535
屏幕数据 / microSD 多路开关
墨水屏电源 SY7636A 与面板、触摸、前光接口（1/2）
墨水屏电源 SY7636A 与面板、触摸、前光接口（2/2）
充电、3V3 升降压、电量计、音频与前光驱动（1/2）
充电、3V3 升降压、电量计、音频与前光驱动（2/2）

Parts:
C202: 1u / VBUS; C202_Core; MPN 0603B105K250NT; LCSC C59302
C209: 1u; C209_Core; MPN 0603B105K250NT; LCSC C59302
D201: LRC8804FDT1G; D201_Core; MPN LRC8804FDT1G; LCSC C2856698
D202: SGM05HU1ALXUGY2G/TR; D202_Core; MPN SGM05HU1ALXUGY2G/TR; LCSC C55274065
J201: U22401-17 / MID-MOUNT; J201_Core; MPN U22401-17
R206: 5.1k ±5% / USB-C Rd; R206_Core; Tolerance 5%; MPN RC-02K512JT; LCSC C453708
R207: 5.1k ±5% / USB-C Rd; R207_Core; Tolerance 5%; MPN RC-02K512JT; LCSC C453708

Connections:
GND: C202.2, C209.2, D201.3 (GND), D201.8 (GND), D202.2 (A), J201.A1, J201.A12, J201.B1, J201.B12, J201.SH, R206.1, R207.1; also elsewhere on the board
USB_CC1: D201.4 (IO4), J201.A5, R206.2
USB_CC2: D201.5 (IO5), J201.B5, R207.2
USB_DM: D201.2 (IO2), J201.A7, J201.B7; also elsewhere on the board
USB_DP: D201.1 (IO1), J201.A6, J201.B6; also elsewhere on the board
VBUS_USB: C202.1, C209.1, D202.1 (K), J201.A4, J201.A9, J201.B4, J201.B9; also elsewhere on the board

Notes on the sheet:
USB-C 接口与 ESD 防护

Parts:
BT301: CR1216 / RTC PRIMARY; BT301_Core; MPN CR1216
C302: 100n / RTC VDD; C302_Core; MPN 0402B104K250NT; LCSC C56392
D306: BAT54WS / RTC charge block; D306_Core; MPN BAT54WS; LCSC C438012
J301: SOLDER LANDING / J301; J301_Core; MPN NOT_A_PURCHASED_PART
J302: SOLDER LANDING / J302; J302_Core; MPN NOT_A_PURCHASED_PART
R301: 1M / SCL PD DNP; R301_Core; MPN RC-02K1004FT; not fitted
R302: 1M / SDA PD DNP; R302_Core; MPN RC-02K1004FT; not fitted
R305: 100k / IRQ PU DNP; R305_Core; MPN RC-02K1003FT; LCSC C140219; not fitted
R306: 10m / CW2217 SHUNT; R306_Core; Tolerance 1%; MPN FRM121WFR010TM; LCSC C7467248
TH301: MF52D-103F3435-100 10k B3435 external NTC; MPN MF52D-103F3435-100; LCSC C394023
TP3: 3V3_AON; TP3_Core; MPN NOT_A_PURCHASED_PART
U302: SD3078; U302_Core; MPN SD3078; LCSC C916255

Connections:
3V3_AON: C302.1, R305.1, TP3.1 (1_1), U302.3 (VDD); also elsewhere on the board
BAT_CELL_N: J301.2; also elsewhere on the board
BAT_CONN_P: J301.1, R306.1; also elsewhere on the board
BAT_PACKP: R306.2; also elsewhere on the board
BQ_TS: J302.1, TH301.1; also elsewhere on the board
EXP_INT: R305.2, U302.7 (INT); also elsewhere on the board
GND: BT301.2, C302.2, J302.2, R301.2, R302.2, TH301.2, U302.6 (GND); also elsewhere on the board
I2C_SCL: R301.1, U302.1 (SCL); also elsewhere on the board
I2C_SDA: R302.1, U302.8 (SDA); also elsewhere on the board
RTC_CELL_P: BT301.1, D306.2 (A)
RTC_VBACKUP: D306.1 (K), U302.5 (VBAT)

Notes on the sheet:
电池接口与 RTC（SD3078）

Parts:
C401: 22u / VIN; C401_Core; MPN 0603X226M100NT; LCSC C60077
C507: 1u / U405 VIN; C507_Core; MPN 0603B105K250NT; LCSC C59302
C516: 1u / U403 VOUT; C516_Core; MPN 0603B105K250NT; LCSC C59302
C532: 1uF 10V X5R / U404 COUT; C532_Core; MPN 0402X105K100NT; LCSC C157353
C533: 1uF 10V X5R / U402 COUT; C533_Core; MPN 0402X105K100NT; LCSC C157353
C534: 1uF 10V X5R / U403 COUT; C534_Core; MPN 0402X105K100NT; LCSC C157353
C535: 1uF 10V X5R / U405 COUT; C535_Core; MPN 0402X105K100NT; LCSC C157353
R507: 100k / AUDIO_EN_PD; R507_Core; Tolerance 1%; Voltage_Rating 50V; MPN RC-02K1003FT; LCSC C140219
R508: 0R / MB6 AUDIO; R508_Core; MPN RS-05000FT; LCSC C132364
R514: 0R / MB3 SD; R514_Core; MPN RS-05000FT; LCSC C132364
R515: 0R / MB4 TOUCH; R515_Core; MPN RS-05000FT; LCSC C132364
R516: 0R / MB5 EPD; R516_Core; MPN RS-05000FT; LCSC C132364
TPG6: GND; TPG6_Core; MPN NOT_A_PURCHASED_PART
U402: SGM2578SDYG/TR; U402_Core; MPN SGM2578SDYG/TR
U403: SGM2578SDYG/TR; U403_Core; MPN SGM2578SDYG/TR
U404: SGM2578SDYG/TR; U404_Core; MPN SGM2578SDYG/TR
U405: SGM2578SDYG/TR; U405_Core; MPN SGM2578SDYG/TR

Connections:
3V3_AON: U402.A2 (VIN_A2), U403.A2 (VIN_A2), U404.A2 (VIN_A2); also elsewhere on the board
3V3_EPD_LOGIC: R516.2; also elsewhere on the board
3V3_EPD_LOGIC_SW: C532.1, R516.1, U404.A1 (VOUT_A1)
3V3_SD: R514.2; also elsewhere on the board
3V3_SD_SW: C533.1, R514.1, U402.A1 (VOUT_A1)
3V3_TOUCH: R515.2; also elsewhere on the board
3V3_TOUCH_SW: C516.1, C534.1, R515.1, U403.A1 (VOUT_A1)
EN_3V3_EPD_LOGIC: U404.B2 (ON_B2); also elsewhere on the board
EN_3V3_SD: U402.B2 (ON_B2); also elsewhere on the board
EN_3V3_TOUCH: U403.B2 (ON_B2); also elsewhere on the board
EN_VSYS_AUDIO: R507.1, U405.B2 (ON_B2); also elsewhere on the board
GND: C401.2, C507.2, C516.2, C532.2, C533.2, C534.2, C535.2, R507.2, TPG6.1 (1_1), U402.B1 (GND_B1), U403.B1 (GND_B1), U404.B1 (GND_B1), U405.B1 (GND_B1); also elsewhere on the board
VSYS_AUDIO: R508.2; also elsewhere on the board
VSYS_AUDIO_SW: C535.1, R508.1, U405.A1 (VOUT_A1)
VSYS_RAW: C401.1, C507.1, U405.A2 (VIN_A2); also elsewhere on the board

Notes on the sheet:
分路负载开关 SGM2578
